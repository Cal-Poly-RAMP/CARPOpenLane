* NGSPICE file created from core.ext - technology: sky130A

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_6 abstract view
.subckt sky130_fd_sc_hd__decap_6 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2_1 abstract view
.subckt sky130_fd_sc_hd__and2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2b_1 abstract view
.subckt sky130_fd_sc_hd__and2b_1 A_N B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_ef_sc_hd__decap_12 abstract view
.subckt sky130_ef_sc_hd__decap_12 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_1 abstract view
.subckt sky130_fd_sc_hd__fill_1 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux2_2 abstract view
.subckt sky130_fd_sc_hd__mux2_2 A0 A1 S VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a211o_1 abstract view
.subckt sky130_fd_sc_hd__a211o_1 A1 A2 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_1 abstract view
.subckt sky130_fd_sc_hd__clkbuf_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_3 abstract view
.subckt sky130_fd_sc_hd__decap_3 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_8 abstract view
.subckt sky130_fd_sc_hd__decap_8 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_2 abstract view
.subckt sky130_fd_sc_hd__fill_2 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfrtp_1 abstract view
.subckt sky130_fd_sc_hd__dfrtp_1 CLK D RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfrtp_4 abstract view
.subckt sky130_fd_sc_hd__dfrtp_4 CLK D RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_1 abstract view
.subckt sky130_fd_sc_hd__nor2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o32a_1 abstract view
.subckt sky130_fd_sc_hd__o32a_1 A1 A2 A3 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_1 abstract view
.subckt sky130_fd_sc_hd__nand2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4_1 abstract view
.subckt sky130_fd_sc_hd__or4_1 A B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21o_1 abstract view
.subckt sky130_fd_sc_hd__a21o_1 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21oi_4 abstract view
.subckt sky130_fd_sc_hd__a21oi_4 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3_1 abstract view
.subckt sky130_fd_sc_hd__and3_1 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux2_1 abstract view
.subckt sky130_fd_sc_hd__mux2_1 A0 A1 S VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31oi_1 abstract view
.subckt sky130_fd_sc_hd__a31oi_1 A1 A2 A3 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__tapvpwrvgnd_1 abstract view
.subckt sky130_fd_sc_hd__tapvpwrvgnd_1 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_4 abstract view
.subckt sky130_fd_sc_hd__decap_4 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o31ai_4 abstract view
.subckt sky130_fd_sc_hd__o31ai_4 A1 A2 A3 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4b_1 abstract view
.subckt sky130_fd_sc_hd__or4b_1 A B C D_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_12 abstract view
.subckt sky130_fd_sc_hd__buf_12 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3_1 abstract view
.subckt sky130_fd_sc_hd__or3_1 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21oi_1 abstract view
.subckt sky130_fd_sc_hd__a21oi_1 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a221o_1 abstract view
.subckt sky130_fd_sc_hd__a221o_1 A1 A2 B1 B2 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2b_1 abstract view
.subckt sky130_fd_sc_hd__or2b_1 A B_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_4 abstract view
.subckt sky130_fd_sc_hd__clkbuf_4 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_2 abstract view
.subckt sky130_fd_sc_hd__buf_2 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfxtp_1 abstract view
.subckt sky130_fd_sc_hd__dfxtp_1 CLK D VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4_1 abstract view
.subckt sky130_fd_sc_hd__and4_1 A B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_2 abstract view
.subckt sky130_fd_sc_hd__nor2_2 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xnor2_2 abstract view
.subckt sky130_fd_sc_hd__xnor2_2 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkdlybuf4s25_1 abstract view
.subckt sky130_fd_sc_hd__clkdlybuf4s25_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__conb_1 abstract view
.subckt sky130_fd_sc_hd__conb_1 VGND VNB VPB VPWR HI LO
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__diode_2 abstract view
.subckt sky130_fd_sc_hd__diode_2 DIODE VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2bb2o_1 abstract view
.subckt sky130_fd_sc_hd__a2bb2o_1 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o211a_1 abstract view
.subckt sky130_fd_sc_hd__o211a_1 A1 A2 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o31a_1 abstract view
.subckt sky130_fd_sc_hd__o31a_1 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_8 abstract view
.subckt sky130_fd_sc_hd__buf_8 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o31a_2 abstract view
.subckt sky130_fd_sc_hd__o31a_2 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2_1 abstract view
.subckt sky130_fd_sc_hd__or2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_1 abstract view
.subckt sky130_fd_sc_hd__inv_1 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2111a_1 abstract view
.subckt sky130_fd_sc_hd__o2111a_1 A1 A2 B1 C1 D1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_2 abstract view
.subckt sky130_fd_sc_hd__inv_2 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_4 abstract view
.subckt sky130_fd_sc_hd__nand2_4 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o221a_1 abstract view
.subckt sky130_fd_sc_hd__o221a_1 A1 A2 B1 B2 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3_1 abstract view
.subckt sky130_fd_sc_hd__nand3_1 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_16 abstract view
.subckt sky130_fd_sc_hd__clkbuf_16 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_4 abstract view
.subckt sky130_fd_sc_hd__buf_4 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o22a_1 abstract view
.subckt sky130_fd_sc_hd__o22a_1 A1 A2 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o311a_1 abstract view
.subckt sky130_fd_sc_hd__o311a_1 A1 A2 A3 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a22o_1 abstract view
.subckt sky130_fd_sc_hd__a22o_1 A1 A2 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21a_2 abstract view
.subckt sky130_fd_sc_hd__o21a_2 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o22ai_1 abstract view
.subckt sky130_fd_sc_hd__o22ai_1 A1 A2 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a32o_1 abstract view
.subckt sky130_fd_sc_hd__a32o_1 A1 A2 A3 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfrtp_2 abstract view
.subckt sky130_fd_sc_hd__dfrtp_2 CLK D RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ai_4 abstract view
.subckt sky130_fd_sc_hd__o21ai_4 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3_4 abstract view
.subckt sky130_fd_sc_hd__nor3_4 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_2 abstract view
.subckt sky130_fd_sc_hd__nand2_2 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31o_4 abstract view
.subckt sky130_fd_sc_hd__a31o_4 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xnor2_1 abstract view
.subckt sky130_fd_sc_hd__xnor2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31o_1 abstract view
.subckt sky130_fd_sc_hd__a31o_1 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3b_1 abstract view
.subckt sky130_fd_sc_hd__or3b_1 A B C_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ai_1 abstract view
.subckt sky130_fd_sc_hd__o21ai_1 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2bb2o_4 abstract view
.subckt sky130_fd_sc_hd__a2bb2o_4 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31o_2 abstract view
.subckt sky130_fd_sc_hd__a31o_2 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4bb_1 abstract view
.subckt sky130_fd_sc_hd__or4bb_1 A B C_N D_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3_2 abstract view
.subckt sky130_fd_sc_hd__and3_2 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3_4 abstract view
.subckt sky130_fd_sc_hd__nand3_4 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o211ai_1 abstract view
.subckt sky130_fd_sc_hd__o211ai_1 A1 A2 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21bo_1 abstract view
.subckt sky130_fd_sc_hd__a21bo_1 A1 A2 B1_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_2 abstract view
.subckt sky130_fd_sc_hd__clkbuf_2 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a22oi_4 abstract view
.subckt sky130_fd_sc_hd__a22oi_4 A1 A2 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xor2_1 abstract view
.subckt sky130_fd_sc_hd__xor2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2b_2 abstract view
.subckt sky130_fd_sc_hd__nor2b_2 A B_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor4b_4 abstract view
.subckt sky130_fd_sc_hd__nor4b_4 A B C D_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a211oi_1 abstract view
.subckt sky130_fd_sc_hd__a211oi_1 A1 A2 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21a_1 abstract view
.subckt sky130_fd_sc_hd__o21a_1 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21oi_2 abstract view
.subckt sky130_fd_sc_hd__a21oi_2 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ba_1 abstract view
.subckt sky130_fd_sc_hd__o21ba_1 A1 A2 B1_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31oi_4 abstract view
.subckt sky130_fd_sc_hd__a31oi_4 A1 A2 A3 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2bb2a_1 abstract view
.subckt sky130_fd_sc_hd__o2bb2a_1 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkinv_2 abstract view
.subckt sky130_fd_sc_hd__clkinv_2 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3b_1 abstract view
.subckt sky130_fd_sc_hd__and3b_1 A_N B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2_2 abstract view
.subckt sky130_fd_sc_hd__and2_2 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a221o_4 abstract view
.subckt sky130_fd_sc_hd__a221o_4 A1 A2 B1 B2 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkinv_4 abstract view
.subckt sky130_fd_sc_hd__clkinv_4 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a41o_1 abstract view
.subckt sky130_fd_sc_hd__a41o_1 A1 A2 A3 A4 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a211o_4 abstract view
.subckt sky130_fd_sc_hd__a211o_4 A1 A2 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21o_4 abstract view
.subckt sky130_fd_sc_hd__a21o_4 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_8 abstract view
.subckt sky130_fd_sc_hd__nor2_8 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2_2 abstract view
.subckt sky130_fd_sc_hd__or2_2 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3_2 abstract view
.subckt sky130_fd_sc_hd__nor3_2 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o221ai_2 abstract view
.subckt sky130_fd_sc_hd__o221ai_2 A1 A2 B1 B2 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_6 abstract view
.subckt sky130_fd_sc_hd__buf_6 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a22o_2 abstract view
.subckt sky130_fd_sc_hd__a22o_2 A1 A2 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21bai_2 abstract view
.subckt sky130_fd_sc_hd__o21bai_2 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o221ai_4 abstract view
.subckt sky130_fd_sc_hd__o221ai_4 A1 A2 B1 B2 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4b_1 abstract view
.subckt sky130_fd_sc_hd__and4b_1 A_N B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4_2 abstract view
.subckt sky130_fd_sc_hd__or4_2 A B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a221oi_2 abstract view
.subckt sky130_fd_sc_hd__a221oi_2 A1 A2 B1 B2 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21bai_1 abstract view
.subckt sky130_fd_sc_hd__o21bai_1 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2b_4 abstract view
.subckt sky130_fd_sc_hd__nor2b_4 A B_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a311o_1 abstract view
.subckt sky130_fd_sc_hd__a311o_1 A1 A2 A3 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux2_4 abstract view
.subckt sky130_fd_sc_hd__mux2_4 A0 A1 S VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlymetal6s2s_1 abstract view
.subckt sky130_fd_sc_hd__dlymetal6s2s_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xnor2_4 abstract view
.subckt sky130_fd_sc_hd__xnor2_4 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21a_4 abstract view
.subckt sky130_fd_sc_hd__o21a_4 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand4_4 abstract view
.subckt sky130_fd_sc_hd__nand4_4 A B C D VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_4 abstract view
.subckt sky130_fd_sc_hd__nor2_4 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xor2_4 abstract view
.subckt sky130_fd_sc_hd__xor2_4 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a311o_4 abstract view
.subckt sky130_fd_sc_hd__a311o_4 A1 A2 A3 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21boi_1 abstract view
.subckt sky130_fd_sc_hd__a21boi_1 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_8 abstract view
.subckt sky130_fd_sc_hd__nand2_8 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31oi_2 abstract view
.subckt sky130_fd_sc_hd__a31oi_2 A1 A2 A3 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand4_2 abstract view
.subckt sky130_fd_sc_hd__nand4_2 A B C D VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a221o_2 abstract view
.subckt sky130_fd_sc_hd__a221o_2 A1 A2 B1 B2 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xor2_2 abstract view
.subckt sky130_fd_sc_hd__xor2_2 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ai_2 abstract view
.subckt sky130_fd_sc_hd__o21ai_2 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a22oi_1 abstract view
.subckt sky130_fd_sc_hd__a22oi_1 A1 A2 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o31ai_2 abstract view
.subckt sky130_fd_sc_hd__o31ai_2 A1 A2 A3 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3_2 abstract view
.subckt sky130_fd_sc_hd__or3_2 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21o_2 abstract view
.subckt sky130_fd_sc_hd__a21o_2 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2bb2o_2 abstract view
.subckt sky130_fd_sc_hd__a2bb2o_2 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4bb_2 abstract view
.subckt sky130_fd_sc_hd__or4bb_2 A B C_N D_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2b_2 abstract view
.subckt sky130_fd_sc_hd__nand2b_2 A_N B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4_4 abstract view
.subckt sky130_fd_sc_hd__and4_4 A B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand4b_1 abstract view
.subckt sky130_fd_sc_hd__nand4b_1 A_N B C D VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4bb_4 abstract view
.subckt sky130_fd_sc_hd__or4bb_4 A B C_N D_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2111ai_4 abstract view
.subckt sky130_fd_sc_hd__o2111ai_4 A1 A2 B1 C1 D1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_6 abstract view
.subckt sky130_fd_sc_hd__inv_6 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor4_2 abstract view
.subckt sky130_fd_sc_hd__nor4_2 A B C D VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o31ai_1 abstract view
.subckt sky130_fd_sc_hd__o31ai_1 A1 A2 A3 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand4_1 abstract view
.subckt sky130_fd_sc_hd__nand4_1 A B C D VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3b_2 abstract view
.subckt sky130_fd_sc_hd__or3b_2 A B C_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3_1 abstract view
.subckt sky130_fd_sc_hd__nor3_1 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a32oi_4 abstract view
.subckt sky130_fd_sc_hd__a32oi_4 A1 A2 A3 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfxtp_2 abstract view
.subckt sky130_fd_sc_hd__dfxtp_2 CLK D VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4bb_1 abstract view
.subckt sky130_fd_sc_hd__and4bb_1 A_N B_N C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3_4 abstract view
.subckt sky130_fd_sc_hd__or3_4 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_4 abstract view
.subckt sky130_fd_sc_hd__inv_4 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o221ai_1 abstract view
.subckt sky130_fd_sc_hd__o221ai_1 A1 A2 B1 B2 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_8 abstract view
.subckt sky130_fd_sc_hd__clkbuf_8 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4bb_2 abstract view
.subckt sky130_fd_sc_hd__and4bb_2 A_N B_N C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux4_2 abstract view
.subckt sky130_fd_sc_hd__mux4_2 A0 A1 A2 A3 S0 S1 VGND VNB VPB VPWR X
.ends

.subckt core VGND VPWR clk_i dmem_addr_o[0] dmem_addr_o[10] dmem_addr_o[11] dmem_addr_o[12]
+ dmem_addr_o[13] dmem_addr_o[14] dmem_addr_o[15] dmem_addr_o[16] dmem_addr_o[17]
+ dmem_addr_o[18] dmem_addr_o[19] dmem_addr_o[1] dmem_addr_o[20] dmem_addr_o[21] dmem_addr_o[22]
+ dmem_addr_o[23] dmem_addr_o[24] dmem_addr_o[25] dmem_addr_o[26] dmem_addr_o[27]
+ dmem_addr_o[28] dmem_addr_o[29] dmem_addr_o[2] dmem_addr_o[30] dmem_addr_o[31] dmem_addr_o[3]
+ dmem_addr_o[4] dmem_addr_o[5] dmem_addr_o[6] dmem_addr_o[7] dmem_addr_o[8] dmem_addr_o[9]
+ dmem_be_o[0] dmem_be_o[1] dmem_be_o[2] dmem_be_o[3] dmem_gnt_i dmem_rdata_i[0] dmem_rdata_i[10]
+ dmem_rdata_i[11] dmem_rdata_i[12] dmem_rdata_i[13] dmem_rdata_i[14] dmem_rdata_i[15]
+ dmem_rdata_i[16] dmem_rdata_i[17] dmem_rdata_i[18] dmem_rdata_i[19] dmem_rdata_i[1]
+ dmem_rdata_i[20] dmem_rdata_i[21] dmem_rdata_i[22] dmem_rdata_i[23] dmem_rdata_i[24]
+ dmem_rdata_i[25] dmem_rdata_i[26] dmem_rdata_i[27] dmem_rdata_i[28] dmem_rdata_i[29]
+ dmem_rdata_i[2] dmem_rdata_i[30] dmem_rdata_i[31] dmem_rdata_i[3] dmem_rdata_i[4]
+ dmem_rdata_i[5] dmem_rdata_i[6] dmem_rdata_i[7] dmem_rdata_i[8] dmem_rdata_i[9]
+ dmem_req_o dmem_rvalid_i dmem_wdata_o[0] dmem_wdata_o[10] dmem_wdata_o[11] dmem_wdata_o[12]
+ dmem_wdata_o[13] dmem_wdata_o[14] dmem_wdata_o[15] dmem_wdata_o[16] dmem_wdata_o[17]
+ dmem_wdata_o[18] dmem_wdata_o[19] dmem_wdata_o[1] dmem_wdata_o[20] dmem_wdata_o[21]
+ dmem_wdata_o[22] dmem_wdata_o[23] dmem_wdata_o[24] dmem_wdata_o[25] dmem_wdata_o[26]
+ dmem_wdata_o[27] dmem_wdata_o[28] dmem_wdata_o[29] dmem_wdata_o[2] dmem_wdata_o[30]
+ dmem_wdata_o[31] dmem_wdata_o[3] dmem_wdata_o[4] dmem_wdata_o[5] dmem_wdata_o[6]
+ dmem_wdata_o[7] dmem_wdata_o[8] dmem_wdata_o[9] dmem_we_o imem_addr_o[0] imem_addr_o[10]
+ imem_addr_o[11] imem_addr_o[12] imem_addr_o[13] imem_addr_o[14] imem_addr_o[15]
+ imem_addr_o[16] imem_addr_o[17] imem_addr_o[18] imem_addr_o[19] imem_addr_o[1] imem_addr_o[20]
+ imem_addr_o[21] imem_addr_o[22] imem_addr_o[23] imem_addr_o[24] imem_addr_o[25]
+ imem_addr_o[26] imem_addr_o[27] imem_addr_o[28] imem_addr_o[29] imem_addr_o[2] imem_addr_o[30]
+ imem_addr_o[31] imem_addr_o[3] imem_addr_o[4] imem_addr_o[5] imem_addr_o[6] imem_addr_o[7]
+ imem_addr_o[8] imem_addr_o[9] imem_be_o[0] imem_be_o[1] imem_be_o[2] imem_be_o[3]
+ imem_gnt_i imem_rdata_i[0] imem_rdata_i[10] imem_rdata_i[11] imem_rdata_i[12] imem_rdata_i[13]
+ imem_rdata_i[14] imem_rdata_i[15] imem_rdata_i[16] imem_rdata_i[17] imem_rdata_i[18]
+ imem_rdata_i[19] imem_rdata_i[1] imem_rdata_i[20] imem_rdata_i[21] imem_rdata_i[22]
+ imem_rdata_i[23] imem_rdata_i[24] imem_rdata_i[25] imem_rdata_i[26] imem_rdata_i[27]
+ imem_rdata_i[28] imem_rdata_i[29] imem_rdata_i[2] imem_rdata_i[30] imem_rdata_i[31]
+ imem_rdata_i[3] imem_rdata_i[4] imem_rdata_i[5] imem_rdata_i[6] imem_rdata_i[7]
+ imem_rdata_i[8] imem_rdata_i[9] imem_req_o imem_rvalid_i imem_wdata_o[0] imem_wdata_o[10]
+ imem_wdata_o[11] imem_wdata_o[12] imem_wdata_o[13] imem_wdata_o[14] imem_wdata_o[15]
+ imem_wdata_o[16] imem_wdata_o[17] imem_wdata_o[18] imem_wdata_o[19] imem_wdata_o[1]
+ imem_wdata_o[20] imem_wdata_o[21] imem_wdata_o[22] imem_wdata_o[23] imem_wdata_o[24]
+ imem_wdata_o[25] imem_wdata_o[26] imem_wdata_o[27] imem_wdata_o[28] imem_wdata_o[29]
+ imem_wdata_o[2] imem_wdata_o[30] imem_wdata_o[31] imem_wdata_o[3] imem_wdata_o[4]
+ imem_wdata_o[5] imem_wdata_o[6] imem_wdata_o[7] imem_wdata_o[8] imem_wdata_o[9]
+ imem_we_o rf_port1_reg_o[0] rf_port1_reg_o[1] rf_port1_reg_o[2] rf_port1_reg_o[3]
+ rf_port1_reg_o[4] rf_port2_reg_o[0] rf_port2_reg_o[1] rf_port2_reg_o[2] rf_port2_reg_o[3]
+ rf_port2_reg_o[4] rf_rs1_i[0] rf_rs1_i[10] rf_rs1_i[11] rf_rs1_i[12] rf_rs1_i[13]
+ rf_rs1_i[14] rf_rs1_i[15] rf_rs1_i[16] rf_rs1_i[17] rf_rs1_i[18] rf_rs1_i[19] rf_rs1_i[1]
+ rf_rs1_i[20] rf_rs1_i[21] rf_rs1_i[22] rf_rs1_i[23] rf_rs1_i[24] rf_rs1_i[25] rf_rs1_i[26]
+ rf_rs1_i[27] rf_rs1_i[28] rf_rs1_i[29] rf_rs1_i[2] rf_rs1_i[30] rf_rs1_i[31] rf_rs1_i[3]
+ rf_rs1_i[4] rf_rs1_i[5] rf_rs1_i[6] rf_rs1_i[7] rf_rs1_i[8] rf_rs1_i[9] rf_rs2_i[0]
+ rf_rs2_i[10] rf_rs2_i[11] rf_rs2_i[12] rf_rs2_i[13] rf_rs2_i[14] rf_rs2_i[15] rf_rs2_i[16]
+ rf_rs2_i[17] rf_rs2_i[18] rf_rs2_i[19] rf_rs2_i[1] rf_rs2_i[20] rf_rs2_i[21] rf_rs2_i[22]
+ rf_rs2_i[23] rf_rs2_i[24] rf_rs2_i[25] rf_rs2_i[26] rf_rs2_i[27] rf_rs2_i[28] rf_rs2_i[29]
+ rf_rs2_i[2] rf_rs2_i[30] rf_rs2_i[31] rf_rs2_i[3] rf_rs2_i[4] rf_rs2_i[5] rf_rs2_i[6]
+ rf_rs2_i[7] rf_rs2_i[8] rf_rs2_i[9] rf_wr_data_o[0] rf_wr_data_o[10] rf_wr_data_o[11]
+ rf_wr_data_o[12] rf_wr_data_o[13] rf_wr_data_o[14] rf_wr_data_o[15] rf_wr_data_o[16]
+ rf_wr_data_o[17] rf_wr_data_o[18] rf_wr_data_o[19] rf_wr_data_o[1] rf_wr_data_o[20]
+ rf_wr_data_o[21] rf_wr_data_o[22] rf_wr_data_o[23] rf_wr_data_o[24] rf_wr_data_o[25]
+ rf_wr_data_o[26] rf_wr_data_o[27] rf_wr_data_o[28] rf_wr_data_o[29] rf_wr_data_o[2]
+ rf_wr_data_o[30] rf_wr_data_o[31] rf_wr_data_o[3] rf_wr_data_o[4] rf_wr_data_o[5]
+ rf_wr_data_o[6] rf_wr_data_o[7] rf_wr_data_o[8] rf_wr_data_o[9] rf_wr_en_o rf_wr_reg_o[0]
+ rf_wr_reg_o[1] rf_wr_reg_o[2] rf_wr_reg_o[3] rf_wr_reg_o[4] rst_ni
XFILLER_0_94_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3155_ _0465_ _0551_ VGND VGND VPWR VPWR _1067_ sky130_fd_sc_hd__and2_1
X_3086_ _0507_ _0988_ VGND VGND VPWR VPWR _0998_ sky130_fd_sc_hd__and2b_1
XFILLER_0_89_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_76_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3988_ net7 net25 i_exec_stage.exec_state_o\[8\] VGND VGND VPWR VPWR _1831_ sky130_fd_sc_hd__mux2_2
XFILLER_0_57_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2939_ i_decode_stage.reg_meta_o\[20\] _0727_ _0386_ _0853_ VGND VGND VPWR VPWR _0854_
+ sky130_fd_sc_hd__a211o_1
XFILLER_0_60_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4609_ _2232_ VGND VGND VPWR VPWR _0194_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_28_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_95_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_48_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_78_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_98_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4960_ clknet_leaf_4_clk_i _0140_ net283 VGND VGND VPWR VPWR i_decode_stage.reg_meta_o\[21\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_19_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4891_ clknet_leaf_19_clk_i _0071_ net296 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[129\]
+ sky130_fd_sc_hd__dfrtp_4
X_3911_ _0444_ _1774_ VGND VGND VPWR VPWR _1781_ sky130_fd_sc_hd__nor2_1
X_3842_ _0448_ _1716_ _1721_ _1501_ _1416_ VGND VGND VPWR VPWR _1722_ sky130_fd_sc_hd__o32a_1
XFILLER_0_46_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3773_ _0773_ _1654_ VGND VGND VPWR VPWR _1656_ sky130_fd_sc_hd__nand2_1
XFILLER_0_89_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2724_ _0647_ _0352_ _0355_ _0357_ VGND VGND VPWR VPWR _0648_ sky130_fd_sc_hd__or4_1
X_2655_ _0448_ _0583_ _0584_ VGND VGND VPWR VPWR _0585_ sky130_fd_sc_hd__a21o_1
X_2586_ _2333_ _0519_ _0521_ VGND VGND VPWR VPWR _0525_ sky130_fd_sc_hd__a21oi_4
X_4325_ net222 net225 net226 VGND VGND VPWR VPWR _2051_ sky130_fd_sc_hd__and3_1
XFILLER_0_10_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4256_ i_decode_stage.decode_state_o\[71\] i_decode_stage.fetch_state_i\[63\] _1982_
+ VGND VGND VPWR VPWR _2007_ sky130_fd_sc_hd__mux2_1
X_4187_ i_decode_stage.fetch_state_i\[29\] i_decode_stage.decode_state_o\[37\] _1967_
+ VGND VGND VPWR VPWR _1972_ sky130_fd_sc_hd__mux2_1
X_3207_ _1111_ _1113_ _1114_ _1105_ VGND VGND VPWR VPWR net165 sky130_fd_sc_hd__a31oi_1
X_3138_ _0465_ _0464_ VGND VGND VPWR VPWR _1050_ sky130_fd_sc_hd__and2_1
XTAP_1129 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1118 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1107 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3069_ _0495_ _0980_ VGND VGND VPWR VPWR _0981_ sky130_fd_sc_hd__nor2_1
XFILLER_0_92_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_445 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_52_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_92_489 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_45_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_60_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_95_250 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_68_442 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_83_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_24_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_417 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2440_ _0386_ _0388_ _0389_ _0390_ VGND VGND VPWR VPWR _0391_ sky130_fd_sc_hd__o31ai_4
XFILLER_0_59_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2371_ _2337_ _2338_ _2339_ _2340_ VGND VGND VPWR VPWR _0325_ sky130_fd_sc_hd__or4b_1
XFILLER_0_75_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4110_ _1926_ VGND VGND VPWR VPWR _1927_ sky130_fd_sc_hd__buf_12
X_5090_ clknet_leaf_27_clk_i net406 net289 VGND VGND VPWR VPWR i_exec_stage.exec_state_o\[65\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_75_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4041_ _0678_ _0682_ _0864_ VGND VGND VPWR VPWR _1859_ sky130_fd_sc_hd__and3_1
XFILLER_0_78_217 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_91_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4943_ clknet_leaf_18_clk_i _0123_ net297 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[139\]
+ sky130_fd_sc_hd__dfrtp_4
XFILLER_0_46_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4874_ clknet_leaf_24_clk_i _0054_ net287 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[58\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_34_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_61_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_61_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3825_ _1691_ _1703_ _1705_ VGND VGND VPWR VPWR _1706_ sky130_fd_sc_hd__or3_1
X_3756_ _0825_ _1003_ _0782_ VGND VGND VPWR VPWR _1640_ sky130_fd_sc_hd__a21oi_1
X_2707_ i_decode_stage.decode_state_o\[124\] _0631_ i_decode_stage.decode_state_o\[147\]
+ _0491_ _0347_ VGND VGND VPWR VPWR _0632_ sky130_fd_sc_hd__a221o_1
X_3687_ _1477_ _1217_ VGND VGND VPWR VPWR _1575_ sky130_fd_sc_hd__or2b_1
X_2638_ _0343_ _0563_ _0569_ VGND VGND VPWR VPWR _0570_ sky130_fd_sc_hd__a21o_1
Xoutput231 net231 VGND VGND VPWR VPWR imem_addr_o[9] sky130_fd_sc_hd__clkbuf_4
Xoutput242 net242 VGND VGND VPWR VPWR rf_wr_data_o[0] sky130_fd_sc_hd__buf_2
Xoutput253 net253 VGND VGND VPWR VPWR rf_wr_data_o[1] sky130_fd_sc_hd__clkbuf_4
Xoutput220 net220 VGND VGND VPWR VPWR imem_addr_o[28] sky130_fd_sc_hd__buf_2
Xoutput264 net264 VGND VGND VPWR VPWR rf_wr_data_o[2] sky130_fd_sc_hd__clkbuf_4
Xoutput275 net275 VGND VGND VPWR VPWR rf_wr_reg_o[0] sky130_fd_sc_hd__buf_2
X_2569_ net250 i_decode_stage.reg_meta_o\[61\] _0457_ VGND VGND VPWR VPWR _0509_ sky130_fd_sc_hd__mux2_1
XFILLER_0_100_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5288_ clknet_leaf_10_clk_i _0287_ VGND VGND VPWR VPWR i_exec_stage.data_fwd_o\[22\]
+ sky130_fd_sc_hd__dfxtp_1
X_4308_ _2040_ VGND VGND VPWR VPWR _0085_ sky130_fd_sc_hd__clkbuf_1
X_4239_ _1998_ VGND VGND VPWR VPWR _0058_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_4_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_84_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_37_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_92_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_28_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4590_ i_decode_stage.reg_meta_o\[66\] net81 _2207_ VGND VGND VPWR VPWR _2223_ sky130_fd_sc_hd__mux2_1
XFILLER_0_43_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3610_ _0413_ _0972_ VGND VGND VPWR VPWR _1502_ sky130_fd_sc_hd__nor2_1
X_3541_ _1332_ _1238_ _1251_ _1087_ _1435_ VGND VGND VPWR VPWR _1436_ sky130_fd_sc_hd__a221o_1
XFILLER_0_24_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_150 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3472_ _0345_ _0656_ _1080_ VGND VGND VPWR VPWR _1370_ sky130_fd_sc_hd__a21oi_1
X_5211_ clknet_leaf_40_clk_i _0210_ net282 VGND VGND VPWR VPWR i_decode_stage.fetch_state_i\[9\]
+ sky130_fd_sc_hd__dfrtp_1
X_2423_ net242 _0363_ _0369_ _0374_ VGND VGND VPWR VPWR _0375_ sky130_fd_sc_hd__and4_1
X_2354_ i_exec_stage.data_fwd_o\[36\] i_decode_stage.decode_state_o\[127\] VGND VGND
+ VPWR VPWR _0308_ sky130_fd_sc_hd__or2b_1
X_5142_ clknet_leaf_8_clk_i net357 net297 VGND VGND VPWR VPWR i_mem_slice_stage.mem_state_o\[49\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_19_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5073_ clknet_leaf_42_clk_i i_decode_stage.decode_state_o\[17\] net280 VGND VGND
+ VPWR VPWR i_exec_stage.exec_state_o\[48\] sky130_fd_sc_hd__dfrtp_1
X_4024_ _0461_ _0786_ VGND VGND VPWR VPWR _1842_ sky130_fd_sc_hd__nor2_1
X_4926_ clknet_leaf_32_clk_i _0106_ net287 VGND VGND VPWR VPWR net209 sky130_fd_sc_hd__dfrtp_4
XFILLER_0_74_253 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_19_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4857_ clknet_leaf_33_clk_i _0037_ net287 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[41\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_51_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3808_ _0756_ _0762_ _1670_ VGND VGND VPWR VPWR _1689_ sky130_fd_sc_hd__or3_1
XFILLER_0_15_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4788_ _2316_ VGND VGND VPWR VPWR _0289_ sky130_fd_sc_hd__clkbuf_1
X_3739_ _0345_ _0464_ _0485_ VGND VGND VPWR VPWR _1624_ sky130_fd_sc_hd__a21o_1
XFILLER_0_100_277 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_97_378 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_38_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_38_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_507 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_518 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_529 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_507 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2972_ _0709_ _0883_ VGND VGND VPWR VPWR _0884_ sky130_fd_sc_hd__nor2_2
XFILLER_0_8_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_29_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_56_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_29_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4711_ net209 i_decode_stage.fetch_state_i\[50\] _1927_ VGND VGND VPWR VPWR _2278_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_56_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4642_ _2248_ VGND VGND VPWR VPWR _0211_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_4_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_71_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4573_ _2214_ VGND VGND VPWR VPWR _0176_ sky130_fd_sc_hd__clkbuf_1
X_3524_ _0424_ _1419_ VGND VGND VPWR VPWR _1420_ sky130_fd_sc_hd__nand2_1
XFILLER_0_97_99 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3455_ _1199_ _1352_ _1353_ VGND VGND VPWR VPWR _1354_ sky130_fd_sc_hd__or3_1
X_2406_ i_decode_stage.decode_state_o\[120\] net276 VGND VGND VPWR VPWR _0359_ sky130_fd_sc_hd__xnor2_2
X_3386_ _1122_ _1134_ _0660_ VGND VGND VPWR VPWR _1288_ sky130_fd_sc_hd__mux2_1
X_5125_ clknet_leaf_14_clk_i i_mem_slice_stage.pre_data\[28\] net294 VGND VGND VPWR
+ VPWR i_mem_slice_stage.mem_state_o\[28\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_34_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5056_ clknet_leaf_15_clk_i net146 net294 VGND VGND VPWR VPWR i_exec_stage.exec_state_o\[31\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_79_301 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4007_ net11 _1829_ _1837_ VGND VGND VPWR VPWR i_mem_slice_stage.pre_data\[19\] sky130_fd_sc_hd__a21o_1
XFILLER_0_35_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4909_ clknet_leaf_22_clk_i _0089_ net288 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[243\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_7_361 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_15_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_62_289 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_30_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_30_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_30_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold30 i_exec_stage.exec_state_o\[31\] VGND VGND VPWR VPWR net367 sky130_fd_sc_hd__clkdlybuf4s25_1
Xhold41 i_exec_stage.exec_state_o\[27\] VGND VGND VPWR VPWR net378 sky130_fd_sc_hd__clkdlybuf4s25_1
Xhold52 i_exec_stage.exec_state_o\[34\] VGND VGND VPWR VPWR net389 sky130_fd_sc_hd__clkdlybuf4s25_1
Xhold63 i_exec_stage.exec_state_o\[49\] VGND VGND VPWR VPWR net400 sky130_fd_sc_hd__clkdlybuf4s25_1
XFILLER_0_26_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xhold74 i_decode_stage.decode_state_o\[36\] VGND VGND VPWR VPWR net411 sky130_fd_sc_hd__clkdlybuf4s25_1
Xcore_310 VGND VGND VPWR VPWR core_310/HI imem_wdata_o[6] sky130_fd_sc_hd__conb_1
Xcore_321 VGND VGND VPWR VPWR core_321/HI imem_wdata_o[17] sky130_fd_sc_hd__conb_1
Xcore_332 VGND VGND VPWR VPWR core_332/HI imem_wdata_o[28] sky130_fd_sc_hd__conb_1
XFILLER_0_53_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_5 _0551_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_315 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_304 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3240_ _0430_ _0889_ _1145_ _0411_ VGND VGND VPWR VPWR _1146_ sky130_fd_sc_hd__a2bb2o_1
XTAP_348 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_337 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_326 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3171_ _0343_ _0656_ _1082_ VGND VGND VPWR VPWR _1083_ sky130_fd_sc_hd__a21o_1
XTAP_359 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_76_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_29_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2955_ _0867_ _0868_ VGND VGND VPWR VPWR _0869_ sky130_fd_sc_hd__and2b_1
X_2886_ _2336_ _2341_ net255 VGND VGND VPWR VPWR _0801_ sky130_fd_sc_hd__and3_1
X_4625_ _2240_ VGND VGND VPWR VPWR _0202_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_32_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_44_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4556_ _2205_ VGND VGND VPWR VPWR _0168_ sky130_fd_sc_hd__clkbuf_1
X_3507_ _0938_ _0954_ VGND VGND VPWR VPWR _1403_ sky130_fd_sc_hd__and2b_1
XFILLER_0_12_197 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4487_ _2170_ VGND VGND VPWR VPWR _0134_ sky130_fd_sc_hd__clkbuf_1
X_3438_ _0867_ _0884_ _1270_ _0868_ VGND VGND VPWR VPWR _1338_ sky130_fd_sc_hd__o211a_1
X_3369_ _1199_ _1268_ _1269_ _1270_ VGND VGND VPWR VPWR _1271_ sky130_fd_sc_hd__o31a_1
XTAP_860 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_871 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5108_ clknet_leaf_14_clk_i i_mem_slice_stage.pre_data\[11\] net294 VGND VGND VPWR
+ VPWR i_mem_slice_stage.mem_state_o\[11\] sky130_fd_sc_hd__dfrtp_1
XTAP_893 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_882 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_429 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5039_ clknet_leaf_10_clk_i net159 net292 VGND VGND VPWR VPWR i_exec_stage.exec_state_o\[14\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_79_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_35_212 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_90_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_31_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput120 rf_rs2_i[29] VGND VGND VPWR VPWR net120 sky130_fd_sc_hd__clkbuf_1
Xinput131 rst_ni VGND VGND VPWR VPWR net131 sky130_fd_sc_hd__buf_8
XFILLER_0_85_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_5_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_26_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2740_ i_mem_slice_stage.mem_state_o\[46\] i_mem_slice_stage.mem_state_o\[7\] _0453_
+ VGND VGND VPWR VPWR _0663_ sky130_fd_sc_hd__mux2_1
X_2671_ _0358_ _0597_ _0598_ _0599_ VGND VGND VPWR VPWR _0600_ sky130_fd_sc_hd__o31a_2
XFILLER_0_26_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4410_ net215 _2112_ VGND VGND VPWR VPWR _2117_ sky130_fd_sc_hd__and2_1
XFILLER_0_41_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4341_ net229 _1840_ VGND VGND VPWR VPWR _2064_ sky130_fd_sc_hd__or2_1
XFILLER_0_22_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4272_ _2015_ VGND VGND VPWR VPWR _0074_ sky130_fd_sc_hd__clkbuf_1
X_3223_ _0709_ VGND VGND VPWR VPWR _1129_ sky130_fd_sc_hd__buf_8
X_3154_ _1065_ VGND VGND VPWR VPWR _1066_ sky130_fd_sc_hd__inv_1
X_3085_ _0994_ _0995_ _0996_ VGND VGND VPWR VPWR _0997_ sky130_fd_sc_hd__a21o_1
XFILLER_0_89_473 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3987_ net30 net16 i_exec_stage.exec_state_o\[8\] VGND VGND VPWR VPWR _1830_ sky130_fd_sc_hd__mux2_1
XFILLER_0_17_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_17_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2938_ _2336_ _2341_ net247 VGND VGND VPWR VPWR _0853_ sky130_fd_sc_hd__and3_1
XFILLER_0_72_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_72_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2869_ _2336_ _2341_ net257 VGND VGND VPWR VPWR _0784_ sky130_fd_sc_hd__and3_1
X_4608_ i_decode_stage.reg_meta_o\[75\] net91 _2207_ VGND VGND VPWR VPWR _2232_ sky130_fd_sc_hd__mux2_1
XFILLER_0_13_473 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4539_ i_decode_stage.decode_state_o\[127\] net49 _2179_ VGND VGND VPWR VPWR _2197_
+ sky130_fd_sc_hd__mux2_1
XTAP_690 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_373 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_90_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_23_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_49 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_64_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_64_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4890_ clknet_leaf_16_clk_i _0070_ net295 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[118\]
+ sky130_fd_sc_hd__dfrtp_1
X_3910_ _0386_ _0826_ _0827_ _0828_ VGND VGND VPWR VPWR _1780_ sky130_fd_sc_hd__o31a_1
XFILLER_0_46_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3841_ _0590_ _1571_ _1720_ _0592_ _0409_ VGND VGND VPWR VPWR _1721_ sky130_fd_sc_hd__o2111a_1
XFILLER_0_13_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3772_ _0773_ _1654_ VGND VGND VPWR VPWR _1655_ sky130_fd_sc_hd__or2_1
X_2723_ i_exec_stage.data_fwd_o\[10\] VGND VGND VPWR VPWR _0647_ sky130_fd_sc_hd__inv_2
XFILLER_0_54_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2654_ _0418_ _0416_ VGND VGND VPWR VPWR _0584_ sky130_fd_sc_hd__nand2_4
X_2585_ _0487_ _0514_ _0523_ VGND VGND VPWR VPWR _0524_ sky130_fd_sc_hd__mux2_1
XFILLER_0_10_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_421 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4324_ net155 _2047_ _2048_ _2049_ _2050_ VGND VGND VPWR VPWR _0091_ sky130_fd_sc_hd__o221a_1
X_4255_ _2006_ VGND VGND VPWR VPWR _0066_ sky130_fd_sc_hd__clkbuf_1
X_4186_ _1971_ VGND VGND VPWR VPWR _0032_ sky130_fd_sc_hd__clkbuf_1
X_3206_ i_exec_stage.alu_out\[1\] i_exec_stage.alu_out\[0\] _1106_ VGND VGND VPWR
+ VPWR _1114_ sky130_fd_sc_hd__nand3_1
X_3137_ _0345_ _0382_ _1048_ VGND VGND VPWR VPWR _1049_ sky130_fd_sc_hd__a21oi_1
XTAP_1119 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1108 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_77_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_49_123 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3068_ _2333_ _0978_ _0979_ VGND VGND VPWR VPWR _0980_ sky130_fd_sc_hd__a21o_1
XFILLER_0_92_457 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_60_365 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xclkbuf_leaf_42_clk_i clknet_2_0__leaf_clk_i VGND VGND VPWR VPWR clknet_leaf_42_clk_i
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_68_454 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_95_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_3_429 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_59_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2370_ _0323_ VGND VGND VPWR VPWR _0324_ sky130_fd_sc_hd__buf_4
X_4040_ _0578_ _0689_ _0693_ _0444_ VGND VGND VPWR VPWR _1858_ sky130_fd_sc_hd__o22a_1
XFILLER_0_91_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_91_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_78_229 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4942_ clknet_leaf_18_clk_i _0122_ net297 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[138\]
+ sky130_fd_sc_hd__dfrtp_4
XFILLER_0_59_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_74_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4873_ clknet_leaf_22_clk_i _0053_ net288 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[57\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_46_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_46_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3824_ _1009_ _1010_ _1676_ _1704_ _1156_ VGND VGND VPWR VPWR _1705_ sky130_fd_sc_hd__o311a_1
XFILLER_0_27_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3755_ _0782_ _1637_ _1158_ VGND VGND VPWR VPWR _1639_ sky130_fd_sc_hd__a21o_1
X_3686_ _1281_ _1208_ _1204_ VGND VGND VPWR VPWR _1574_ sky130_fd_sc_hd__a21o_1
XFILLER_0_40_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2706_ i_decode_stage.decode_state_o\[234\] VGND VGND VPWR VPWR _0631_ sky130_fd_sc_hd__inv_2
X_2637_ _0465_ _0568_ VGND VGND VPWR VPWR _0569_ sky130_fd_sc_hd__and2_1
Xoutput210 net210 VGND VGND VPWR VPWR imem_addr_o[19] sky130_fd_sc_hd__clkbuf_4
Xoutput243 net243 VGND VGND VPWR VPWR rf_wr_data_o[10] sky130_fd_sc_hd__buf_2
Xoutput232 net232 VGND VGND VPWR VPWR rf_port1_reg_o[0] sky130_fd_sc_hd__clkbuf_4
Xoutput221 net221 VGND VGND VPWR VPWR imem_addr_o[29] sky130_fd_sc_hd__clkbuf_4
Xoutput265 net265 VGND VGND VPWR VPWR rf_wr_data_o[30] sky130_fd_sc_hd__buf_2
Xoutput254 net254 VGND VGND VPWR VPWR rf_wr_data_o[20] sky130_fd_sc_hd__buf_2
Xoutput276 net276 VGND VGND VPWR VPWR rf_wr_reg_o[1] sky130_fd_sc_hd__buf_2
X_5356_ net50 VGND VGND VPWR VPWR net241 sky130_fd_sc_hd__clkbuf_1
X_2568_ i_mem_slice_stage.mem_state_o\[88\] _0452_ _0508_ _0455_ VGND VGND VPWR VPWR
+ net250 sky130_fd_sc_hd__a22o_1
X_2499_ _0384_ net193 _0446_ VGND VGND VPWR VPWR _0447_ sky130_fd_sc_hd__o21a_2
XFILLER_0_10_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5287_ clknet_leaf_9_clk_i _0286_ VGND VGND VPWR VPWR i_exec_stage.data_fwd_o\[21\]
+ sky130_fd_sc_hd__dfxtp_1
X_4307_ i_decode_stage.decode_state_o\[239\] _2039_ _2012_ VGND VGND VPWR VPWR _2040_
+ sky130_fd_sc_hd__mux2_1
X_4238_ i_decode_stage.decode_state_o\[62\] i_decode_stage.fetch_state_i\[54\] _1982_
+ VGND VGND VPWR VPWR _1998_ sky130_fd_sc_hd__mux2_1
XFILLER_0_97_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4169_ _1962_ VGND VGND VPWR VPWR _0024_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_92_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_21_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_33_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_60_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_60_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_68_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3540_ _1241_ _1326_ _1434_ _1041_ VGND VGND VPWR VPWR _1435_ sky130_fd_sc_hd__o22ai_1
XFILLER_0_101_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_365 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_51_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3471_ _0590_ _0594_ _1130_ _1368_ _1216_ VGND VGND VPWR VPWR _1369_ sky130_fd_sc_hd__a32o_1
X_5210_ clknet_leaf_40_clk_i _0209_ net281 VGND VGND VPWR VPWR i_decode_stage.fetch_state_i\[8\]
+ sky130_fd_sc_hd__dfrtp_1
X_2422_ _0373_ VGND VGND VPWR VPWR _0374_ sky130_fd_sc_hd__buf_2
X_5141_ clknet_leaf_12_clk_i net386 net293 VGND VGND VPWR VPWR i_mem_slice_stage.mem_state_o\[48\]
+ sky130_fd_sc_hd__dfrtp_1
X_2353_ i_decode_stage.decode_state_o\[126\] i_exec_stage.data_fwd_o\[35\] VGND VGND
+ VPWR VPWR _0307_ sky130_fd_sc_hd__or2b_1
X_5072_ clknet_leaf_43_clk_i i_decode_stage.decode_state_o\[16\] net280 VGND VGND
+ VPWR VPWR i_exec_stage.exec_state_o\[47\] sky130_fd_sc_hd__dfrtp_1
X_4023_ _0461_ _0786_ _0794_ _0481_ VGND VGND VPWR VPWR _1841_ sky130_fd_sc_hd__a22o_1
XFILLER_0_79_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_35_83 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4925_ clknet_leaf_31_clk_i _0105_ net286 VGND VGND VPWR VPWR net208 sky130_fd_sc_hd__dfrtp_2
XFILLER_0_74_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4856_ clknet_leaf_33_clk_i _0036_ net288 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[40\]
+ sky130_fd_sc_hd__dfrtp_1
X_3807_ _1688_ VGND VGND VPWR VPWR net148 sky130_fd_sc_hd__inv_2
X_4787_ i_exec_stage.data_fwd_o\[24\] net145 _1838_ VGND VGND VPWR VPWR _2316_ sky130_fd_sc_hd__mux2_1
X_3738_ _1553_ VGND VGND VPWR VPWR _1623_ sky130_fd_sc_hd__inv_2
XFILLER_0_42_184 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3669_ _0413_ _0981_ VGND VGND VPWR VPWR _1558_ sky130_fd_sc_hd__nor2_1
XFILLER_0_100_289 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_53_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_65_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_508 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_519 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2971_ _0451_ _0693_ _0694_ VGND VGND VPWR VPWR _0883_ sky130_fd_sc_hd__o21ai_4
X_4710_ _2277_ VGND VGND VPWR VPWR _0250_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_44_405 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4641_ i_decode_stage.fetch_state_i\[10\] _2073_ _2234_ VGND VGND VPWR VPWR _2248_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_21_30 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_44_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_56_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4572_ i_decode_stage.reg_meta_o\[57\] net71 _2207_ VGND VGND VPWR VPWR _2214_ sky130_fd_sc_hd__mux2_1
XFILLER_0_71_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3523_ _0417_ _0640_ _0832_ _0413_ _1418_ VGND VGND VPWR VPWR _1419_ sky130_fd_sc_hd__o221a_1
X_3454_ _1149_ _0945_ _1351_ _1198_ VGND VGND VPWR VPWR _1353_ sky130_fd_sc_hd__a22o_1
X_2405_ _0352_ _0355_ _0357_ VGND VGND VPWR VPWR _0358_ sky130_fd_sc_hd__nor3_4
X_3385_ _1074_ _0707_ VGND VGND VPWR VPWR _1287_ sky130_fd_sc_hd__nand2_2
X_5124_ clknet_leaf_14_clk_i i_mem_slice_stage.pre_data\[27\] net294 VGND VGND VPWR
+ VPWR i_mem_slice_stage.mem_state_o\[27\] sky130_fd_sc_hd__dfrtp_1
X_5055_ clknet_leaf_15_clk_i net145 net293 VGND VGND VPWR VPWR i_exec_stage.exec_state_o\[30\]
+ sky130_fd_sc_hd__dfrtp_1
X_4006_ net10 _1829_ _1837_ VGND VGND VPWR VPWR i_mem_slice_stage.pre_data\[18\] sky130_fd_sc_hd__a21o_1
XFILLER_0_79_313 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_27_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_94_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_47_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4908_ clknet_2_3__leaf_clk_i _0088_ net296 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[242\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_7_373 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4839_ clknet_leaf_31_clk_i _0019_ net285 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[23\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_15_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_30_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold31 i_exec_stage.exec_state_o\[32\] VGND VGND VPWR VPWR net368 sky130_fd_sc_hd__clkdlybuf4s25_1
Xhold20 i_exec_stage.exec_state_o\[17\] VGND VGND VPWR VPWR net357 sky130_fd_sc_hd__clkdlybuf4s25_1
Xhold64 i_exec_stage.reg_meta_o\[4\] VGND VGND VPWR VPWR net401 sky130_fd_sc_hd__clkdlybuf4s25_1
Xhold42 i_exec_stage.exec_state_o\[41\] VGND VGND VPWR VPWR net379 sky130_fd_sc_hd__clkdlybuf4s25_1
Xhold53 i_exec_stage.exec_state_o\[25\] VGND VGND VPWR VPWR net390 sky130_fd_sc_hd__clkdlybuf4s25_1
Xhold75 i_decode_stage.decode_state_o\[24\] VGND VGND VPWR VPWR net412 sky130_fd_sc_hd__clkdlybuf4s25_1
XFILLER_0_97_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xcore_300 VGND VGND VPWR VPWR core_300/HI imem_be_o[0] sky130_fd_sc_hd__conb_1
Xcore_311 VGND VGND VPWR VPWR core_311/HI imem_wdata_o[7] sky130_fd_sc_hd__conb_1
Xcore_322 VGND VGND VPWR VPWR core_322/HI imem_wdata_o[18] sky130_fd_sc_hd__conb_1
Xcore_333 VGND VGND VPWR VPWR core_333/HI imem_wdata_o[29] sky130_fd_sc_hd__conb_1
XFILLER_0_97_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_93_393 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_34_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_1_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_6 _0551_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_305 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_349 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_338 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_327 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_316 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3170_ _0343_ _0949_ VGND VGND VPWR VPWR _1082_ sky130_fd_sc_hd__nor2_1
XFILLER_0_83_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2954_ _0683_ _0866_ VGND VGND VPWR VPWR _0868_ sky130_fd_sc_hd__nand2_1
XFILLER_0_72_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_84_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_17_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_44_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2885_ _0791_ _0799_ VGND VGND VPWR VPWR _0800_ sky130_fd_sc_hd__nor2_1
XFILLER_0_4_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4624_ net211 i_exec_stage.alu_out\[1\] _2042_ VGND VGND VPWR VPWR _2240_ sky130_fd_sc_hd__mux2_1
X_4555_ i_decode_stage.reg_meta_o\[49\] net94 _2179_ VGND VGND VPWR VPWR _2205_ sky130_fd_sc_hd__mux2_1
XFILLER_0_4_365 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_12_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3506_ _1156_ _1384_ _1385_ _1402_ VGND VGND VPWR VPWR net133 sky130_fd_sc_hd__a31o_4
XFILLER_0_12_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4486_ i_decode_stage.reg_meta_o\[15\] net130 _2012_ VGND VGND VPWR VPWR _2170_ sky130_fd_sc_hd__mux2_1
X_3437_ _0876_ _0881_ VGND VGND VPWR VPWR _1337_ sky130_fd_sc_hd__nor2_1
XTAP_850 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3368_ _0677_ _0880_ VGND VGND VPWR VPWR _1270_ sky130_fd_sc_hd__nand2_1
XTAP_861 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5107_ clknet_leaf_14_clk_i i_mem_slice_stage.pre_data\[10\] net294 VGND VGND VPWR
+ VPWR i_mem_slice_stage.mem_state_o\[10\] sky130_fd_sc_hd__dfrtp_1
XTAP_894 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_883 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_872 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3299_ _1156_ _1161_ _1166_ _1203_ VGND VGND VPWR VPWR net155 sky130_fd_sc_hd__a31o_4
X_5038_ clknet_leaf_10_clk_i net158 net292 VGND VGND VPWR VPWR i_exec_stage.exec_state_o\[13\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_67_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_393 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_90_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput110 rf_rs2_i[1] VGND VGND VPWR VPWR net110 sky130_fd_sc_hd__clkbuf_1
Xinput121 rf_rs2_i[2] VGND VGND VPWR VPWR net121 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_85_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_81_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2670_ i_exec_stage.data_fwd_o\[14\] _0352_ _0355_ _0357_ VGND VGND VPWR VPWR _0599_
+ sky130_fd_sc_hd__or4_1
XFILLER_0_41_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_22_441 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4340_ net229 _2059_ VGND VGND VPWR VPWR _2063_ sky130_fd_sc_hd__xnor2_1
X_4271_ i_decode_stage.decode_state_o\[132\] net54 _2012_ VGND VGND VPWR VPWR _2015_
+ sky130_fd_sc_hd__mux2_1
X_3222_ _0448_ _1127_ _0584_ VGND VGND VPWR VPWR _1128_ sky130_fd_sc_hd__a21o_1
X_3153_ _1062_ _1064_ _0394_ VGND VGND VPWR VPWR _1065_ sky130_fd_sc_hd__mux2_1
X_3084_ _0512_ _0963_ VGND VGND VPWR VPWR _0996_ sky130_fd_sc_hd__and2b_1
XFILLER_0_89_485 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3986_ _1807_ VGND VGND VPWR VPWR _1829_ sky130_fd_sc_hd__buf_4
X_2937_ _0850_ _0851_ VGND VGND VPWR VPWR _0852_ sky130_fd_sc_hd__nand2_2
XFILLER_0_17_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4607_ _2231_ VGND VGND VPWR VPWR _0193_ sky130_fd_sc_hd__clkbuf_1
X_2868_ _0773_ _0782_ VGND VGND VPWR VPWR _0783_ sky130_fd_sc_hd__nand2_1
X_2799_ _0713_ _0717_ VGND VGND VPWR VPWR _0718_ sky130_fd_sc_hd__nor2_1
XFILLER_0_13_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4538_ _2196_ VGND VGND VPWR VPWR _0159_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_13_485 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4469_ _2161_ VGND VGND VPWR VPWR _0125_ sky130_fd_sc_hd__clkbuf_1
XTAP_680 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_691 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_67_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_64_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_58_157 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3840_ _0662_ _1644_ _1717_ _1719_ _0707_ VGND VGND VPWR VPWR _1720_ sky130_fd_sc_hd__a221o_1
XFILLER_0_86_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_27_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_73_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3771_ _0825_ _1003_ _0782_ _1006_ VGND VGND VPWR VPWR _1654_ sky130_fd_sc_hd__a31o_1
XFILLER_0_14_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2722_ _0363_ _0369_ _0374_ _0645_ VGND VGND VPWR VPWR _0646_ sky130_fd_sc_hd__and4_1
XFILLER_0_42_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_89_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2653_ _0524_ _0573_ _0582_ VGND VGND VPWR VPWR _0583_ sky130_fd_sc_hd__mux2_1
X_2584_ _0522_ VGND VGND VPWR VPWR _0523_ sky130_fd_sc_hd__buf_12
XFILLER_0_10_433 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4323_ net225 _1840_ VGND VGND VPWR VPWR _2050_ sky130_fd_sc_hd__or2_1
XFILLER_0_10_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_38_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4254_ i_decode_stage.decode_state_o\[70\] i_decode_stage.fetch_state_i\[62\] _1982_
+ VGND VGND VPWR VPWR _2006_ sky130_fd_sc_hd__mux2_1
X_4185_ i_decode_stage.fetch_state_i\[28\] i_decode_stage.decode_state_o\[36\] _1967_
+ VGND VGND VPWR VPWR _1971_ sky130_fd_sc_hd__mux2_1
XFILLER_0_38_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3205_ i_exec_stage.alu_out\[0\] _1112_ i_exec_stage.alu_out\[1\] VGND VGND VPWR
+ VPWR _1113_ sky130_fd_sc_hd__or3b_1
X_3136_ _0382_ _1046_ _1047_ _0424_ VGND VGND VPWR VPWR _1048_ sky130_fd_sc_hd__o211a_1
XFILLER_0_96_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3067_ i_decode_stage.decode_state_o\[59\] _0731_ _0733_ VGND VGND VPWR VPWR _0979_
+ sky130_fd_sc_hd__a21oi_1
XTAP_1109 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_77_488 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_9_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_64_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_92_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3969_ net9 _1815_ _1817_ _1810_ VGND VGND VPWR VPWR _1818_ sky130_fd_sc_hd__a22o_1
XFILLER_0_33_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_70_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_60_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_60_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_68_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_68_499 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4941_ clknet_leaf_19_clk_i _0121_ net296 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[137\]
+ sky130_fd_sc_hd__dfrtp_4
XFILLER_0_86_274 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4872_ clknet_leaf_29_clk_i _0052_ net291 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[56\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_46_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3823_ _1010_ _1676_ _1009_ VGND VGND VPWR VPWR _1704_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_15_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3754_ _0782_ _1637_ VGND VGND VPWR VPWR _1638_ sky130_fd_sc_hd__nor2_2
X_3685_ _0590_ _1571_ _1572_ VGND VGND VPWR VPWR _1573_ sky130_fd_sc_hd__a21o_1
X_2705_ _0358_ _0627_ _0628_ _0629_ VGND VGND VPWR VPWR _0630_ sky130_fd_sc_hd__o31a_2
XFILLER_0_42_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_42_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput200 net200 VGND VGND VPWR VPWR imem_addr_o[0] sky130_fd_sc_hd__buf_2
X_2636_ _0451_ _0566_ _0462_ _0567_ VGND VGND VPWR VPWR _0568_ sky130_fd_sc_hd__a2bb2o_4
Xoutput244 net244 VGND VGND VPWR VPWR rf_wr_data_o[11] sky130_fd_sc_hd__buf_2
Xoutput211 net211 VGND VGND VPWR VPWR imem_addr_o[1] sky130_fd_sc_hd__buf_2
Xoutput222 net222 VGND VGND VPWR VPWR imem_addr_o[2] sky130_fd_sc_hd__buf_2
Xoutput233 net233 VGND VGND VPWR VPWR rf_port1_reg_o[1] sky130_fd_sc_hd__clkbuf_4
Xoutput266 net266 VGND VGND VPWR VPWR rf_wr_data_o[31] sky130_fd_sc_hd__buf_2
Xoutput255 net255 VGND VGND VPWR VPWR rf_wr_data_o[21] sky130_fd_sc_hd__clkbuf_4
X_5355_ net49 VGND VGND VPWR VPWR net240 sky130_fd_sc_hd__clkbuf_1
Xoutput277 net277 VGND VGND VPWR VPWR rf_wr_reg_o[2] sky130_fd_sc_hd__buf_2
X_2567_ i_mem_slice_stage.mem_state_o\[56\] i_mem_slice_stage.mem_state_o\[17\] _0453_
+ VGND VGND VPWR VPWR _0508_ sky130_fd_sc_hd__mux2_1
X_2498_ i_decode_stage.decode_state_o\[128\] _0337_ i_decode_stage.decode_state_o\[232\]
+ _0445_ VGND VGND VPWR VPWR _0446_ sky130_fd_sc_hd__a31o_2
X_5286_ clknet_leaf_6_clk_i _0285_ VGND VGND VPWR VPWR i_exec_stage.data_fwd_o\[20\]
+ sky130_fd_sc_hd__dfxtp_1
X_4306_ net57 _2031_ _2038_ _2033_ VGND VGND VPWR VPWR _2039_ sky130_fd_sc_hd__a31o_1
X_4237_ _1997_ VGND VGND VPWR VPWR _0057_ sky130_fd_sc_hd__clkbuf_1
X_4168_ i_decode_stage.fetch_state_i\[20\] i_decode_stage.decode_state_o\[28\] _1936_
+ VGND VGND VPWR VPWR _1962_ sky130_fd_sc_hd__mux2_1
XFILLER_0_65_81 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4099_ _1859_ _1860_ _1853_ _1865_ VGND VGND VPWR VPWR _1917_ sky130_fd_sc_hd__or4bb_1
X_3119_ i_decode_stage.decode_state_o\[71\] _0731_ VGND VGND VPWR VPWR _1031_ sky130_fd_sc_hd__nand2_1
XFILLER_0_18_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_193 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_60_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_33_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_28_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_24_377 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3470_ _0707_ _1120_ _1322_ VGND VGND VPWR VPWR _1368_ sky130_fd_sc_hd__o21ai_1
X_2421_ i_decode_stage.reg_meta_o\[81\] net274 _0371_ _0372_ VGND VGND VPWR VPWR _0373_
+ sky130_fd_sc_hd__and4_1
XFILLER_0_10_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2352_ _2336_ _2341_ i_decode_stage.reg_meta_o\[6\] VGND VGND VPWR VPWR _0306_ sky130_fd_sc_hd__a21o_1
X_5140_ clknet_leaf_11_clk_i net397 net292 VGND VGND VPWR VPWR i_mem_slice_stage.mem_state_o\[47\]
+ sky130_fd_sc_hd__dfrtp_1
X_5071_ clknet_leaf_42_clk_i i_decode_stage.decode_state_o\[15\] net280 VGND VGND
+ VPWR VPWR i_exec_stage.exec_state_o\[46\] sky130_fd_sc_hd__dfrtp_1
X_4022_ _0722_ VGND VGND VPWR VPWR _1840_ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_94_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4924_ clknet_leaf_31_clk_i _0104_ net286 VGND VGND VPWR VPWR net207 sky130_fd_sc_hd__dfrtp_2
XFILLER_0_35_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_19_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4855_ clknet_leaf_24_clk_i _0035_ net287 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[39\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_74_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4786_ _2315_ VGND VGND VPWR VPWR _0288_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_55_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3806_ _1673_ _1677_ _1687_ VGND VGND VPWR VPWR _1688_ sky130_fd_sc_hd__and3_2
Xclkbuf_leaf_41_clk_i clknet_2_0__leaf_clk_i VGND VGND VPWR VPWR clknet_leaf_41_clk_i
+ sky130_fd_sc_hd__clkbuf_16
X_3737_ _0791_ _1620_ _1621_ _0429_ i_decode_stage.decode_state_o\[239\] VGND VGND
+ VPWR VPWR _1622_ sky130_fd_sc_hd__o2111a_1
XFILLER_0_15_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_42_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3668_ _1129_ _1555_ _1556_ VGND VGND VPWR VPWR _1557_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_100_202 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2619_ net262 i_decode_stage.reg_meta_o\[72\] _0457_ VGND VGND VPWR VPWR _0553_ sky130_fd_sc_hd__mux2_1
X_3599_ _1408_ _1489_ _1490_ _1340_ VGND VGND VPWR VPWR _1491_ sky130_fd_sc_hd__a22o_1
X_5269_ clknet_leaf_0_clk_i _0268_ VGND VGND VPWR VPWR i_exec_stage.data_fwd_o\[3\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_65_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_65_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_80_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_509 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xfanout290 net291 VGND VGND VPWR VPWR net290 sky130_fd_sc_hd__buf_12
XFILLER_0_72_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_96_380 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2970_ _0876_ _0881_ VGND VGND VPWR VPWR _0882_ sky130_fd_sc_hd__nand2_1
XFILLER_0_16_108 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4640_ _2247_ VGND VGND VPWR VPWR _0210_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_44_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_42 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4571_ _2213_ VGND VGND VPWR VPWR _0175_ sky130_fd_sc_hd__clkbuf_1
X_3522_ _1198_ _0832_ VGND VGND VPWR VPWR _1418_ sky130_fd_sc_hd__nand2_1
X_3453_ _0413_ _1351_ VGND VGND VPWR VPWR _1352_ sky130_fd_sc_hd__nor2_1
Xclkbuf_2_0__f_clk_i clknet_0_clk_i VGND VGND VPWR VPWR clknet_2_0__leaf_clk_i sky130_fd_sc_hd__clkbuf_16
X_2404_ i_decode_stage.reg_meta_o\[81\] _0319_ _0356_ VGND VGND VPWR VPWR _0357_ sky130_fd_sc_hd__nand3_4
X_5123_ clknet_leaf_14_clk_i i_mem_slice_stage.pre_data\[26\] net294 VGND VGND VPWR
+ VPWR i_mem_slice_stage.mem_state_o\[26\] sky130_fd_sc_hd__dfrtp_1
X_3384_ _1281_ _1285_ VGND VGND VPWR VPWR _1286_ sky130_fd_sc_hd__and2_1
X_5054_ clknet_leaf_15_clk_i net144 net294 VGND VGND VPWR VPWR i_exec_stage.exec_state_o\[29\]
+ sky130_fd_sc_hd__dfrtp_1
X_4005_ net9 _1829_ _1837_ VGND VGND VPWR VPWR i_mem_slice_stage.pre_data\[17\] sky130_fd_sc_hd__a21o_1
XFILLER_0_79_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4907_ clknet_leaf_20_clk_i _0087_ net296 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[241\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_90_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4838_ clknet_leaf_30_clk_i _0018_ net285 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[22\]
+ sky130_fd_sc_hd__dfrtp_2
XFILLER_0_62_236 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_7_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4769_ i_exec_stage.data_fwd_o\[15\] net136 _1839_ VGND VGND VPWR VPWR _2307_ sky130_fd_sc_hd__mux2_1
XFILLER_0_11_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold10 i_exec_stage.reg_meta_o\[0\] VGND VGND VPWR VPWR net347 sky130_fd_sc_hd__clkdlybuf4s25_1
Xhold32 i_exec_stage.exec_state_o\[26\] VGND VGND VPWR VPWR net369 sky130_fd_sc_hd__clkdlybuf4s25_1
Xhold21 i_exec_stage.exec_state_o\[14\] VGND VGND VPWR VPWR net358 sky130_fd_sc_hd__clkdlybuf4s25_1
Xhold54 i_exec_stage.exec_state_o\[46\] VGND VGND VPWR VPWR net391 sky130_fd_sc_hd__clkdlybuf4s25_1
Xhold43 i_exec_stage.exec_state_o\[66\] VGND VGND VPWR VPWR net380 sky130_fd_sc_hd__clkdlybuf4s25_1
Xhold65 i_exec_stage.exec_state_o\[21\] VGND VGND VPWR VPWR net402 sky130_fd_sc_hd__clkdlybuf4s25_1
Xhold76 i_exec_stage.exec_state_o\[36\] VGND VGND VPWR VPWR net413 sky130_fd_sc_hd__clkdlybuf4s25_1
XFILLER_0_97_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xcore_301 VGND VGND VPWR VPWR core_301/HI imem_be_o[1] sky130_fd_sc_hd__conb_1
Xcore_312 VGND VGND VPWR VPWR core_312/HI imem_wdata_o[8] sky130_fd_sc_hd__conb_1
Xcore_323 VGND VGND VPWR VPWR core_323/HI imem_wdata_o[19] sky130_fd_sc_hd__conb_1
Xcore_334 VGND VGND VPWR VPWR core_334/HI imem_wdata_o[30] sky130_fd_sc_hd__conb_1
XFILLER_0_93_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_21_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_483 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XANTENNA_7 _0565_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_306 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_188 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_339 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_328 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_317 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_76_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2953_ _0683_ _0866_ VGND VGND VPWR VPWR _0867_ sky130_fd_sc_hd__nor2_1
XFILLER_0_84_350 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_8_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_44_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_32_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2884_ _0797_ _0798_ VGND VGND VPWR VPWR _0799_ sky130_fd_sc_hd__nor2_1
XFILLER_0_25_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4623_ _2239_ VGND VGND VPWR VPWR _0201_ sky130_fd_sc_hd__clkbuf_1
X_4554_ _2204_ VGND VGND VPWR VPWR _0167_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_4_377 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_52_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3505_ _1158_ _1387_ _1401_ VGND VGND VPWR VPWR _1402_ sky130_fd_sc_hd__o21ai_1
X_4485_ _2169_ VGND VGND VPWR VPWR _0133_ sky130_fd_sc_hd__clkbuf_1
X_3436_ _0912_ _1321_ _1335_ VGND VGND VPWR VPWR _1336_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_57_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3367_ _0417_ _0677_ _1267_ _1198_ VGND VGND VPWR VPWR _1269_ sky130_fd_sc_hd__a2bb2o_1
XTAP_840 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_851 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_862 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5106_ clknet_leaf_14_clk_i i_mem_slice_stage.pre_data\[9\] net294 VGND VGND VPWR
+ VPWR i_mem_slice_stage.mem_state_o\[9\] sky130_fd_sc_hd__dfrtp_1
XTAP_895 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_884 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_873 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3298_ _1158_ _1168_ _1190_ _1202_ VGND VGND VPWR VPWR _1203_ sky130_fd_sc_hd__o211ai_1
X_5037_ clknet_leaf_11_clk_i net157 net292 VGND VGND VPWR VPWR i_exec_stage.exec_state_o\[12\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_79_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_79_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput100 rf_rs2_i[10] VGND VGND VPWR VPWR net100 sky130_fd_sc_hd__clkbuf_1
Xinput111 rf_rs2_i[20] VGND VGND VPWR VPWR net111 sky130_fd_sc_hd__clkbuf_1
Xinput122 rf_rs2_i[30] VGND VGND VPWR VPWR net122 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_98_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_58_317 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_66_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_22_453 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4270_ _2014_ VGND VGND VPWR VPWR _0073_ sky130_fd_sc_hd__clkbuf_1
X_3221_ _0707_ _1120_ _1126_ VGND VGND VPWR VPWR _1127_ sky130_fd_sc_hd__a21bo_1
X_3152_ _0343_ _0556_ _1063_ VGND VGND VPWR VPWR _1064_ sky130_fd_sc_hd__a21o_1
X_3083_ _0622_ _0971_ VGND VGND VPWR VPWR _0995_ sky130_fd_sc_hd__and2b_1
XFILLER_0_89_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3985_ net29 _1809_ _1828_ VGND VGND VPWR VPWR i_mem_slice_stage.pre_data\[6\] sky130_fd_sc_hd__a21o_1
XFILLER_0_9_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_17_225 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2936_ _0617_ _0849_ VGND VGND VPWR VPWR _0851_ sky130_fd_sc_hd__or2_1
XFILLER_0_17_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2867_ _0781_ VGND VGND VPWR VPWR _0782_ sky130_fd_sc_hd__clkbuf_2
XFILLER_0_87_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_4_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4606_ i_decode_stage.reg_meta_o\[74\] net90 _2207_ VGND VGND VPWR VPWR _2231_ sky130_fd_sc_hd__mux2_1
X_2798_ _0707_ _0716_ VGND VGND VPWR VPWR _0717_ sky130_fd_sc_hd__or2_1
X_4537_ i_decode_stage.decode_state_o\[126\] net48 _2179_ VGND VGND VPWR VPWR _2196_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_40_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4468_ i_decode_stage.reg_meta_o\[6\] net99 _2012_ VGND VGND VPWR VPWR _2161_ sky130_fd_sc_hd__mux2_1
X_3419_ _1317_ _1318_ VGND VGND VPWR VPWR _1319_ sky130_fd_sc_hd__nor2_1
X_4399_ net142 _2042_ _2045_ _2107_ _2108_ VGND VGND VPWR VPWR _0108_ sky130_fd_sc_hd__a221o_1
XTAP_670 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_681 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_692 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_48_372 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_55_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_90_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_48_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_86_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_86_489 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_27_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_46_309 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_58_169 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3770_ _1638_ _1639_ _1653_ VGND VGND VPWR VPWR net146 sky130_fd_sc_hd__o21ai_4
X_2721_ i_mem_slice_stage.mem_state_o\[80\] _0328_ _0644_ _0330_ VGND VGND VPWR VPWR
+ _0645_ sky130_fd_sc_hd__a22oi_4
XFILLER_0_66_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2652_ _0581_ VGND VGND VPWR VPWR _0582_ sky130_fd_sc_hd__buf_4
X_2583_ _2333_ _0519_ _0521_ VGND VGND VPWR VPWR _0522_ sky130_fd_sc_hd__a21o_1
XFILLER_0_1_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_10_445 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4322_ net222 net225 VGND VGND VPWR VPWR _2049_ sky130_fd_sc_hd__xor2_1
X_4253_ _2005_ VGND VGND VPWR VPWR _0065_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_10_489 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3204_ i_decode_stage.decode_state_o\[0\] _1110_ VGND VGND VPWR VPWR _1112_ sky130_fd_sc_hd__nand2_2
X_4184_ _1970_ VGND VGND VPWR VPWR _0031_ sky130_fd_sc_hd__clkbuf_1
X_3135_ i_decode_stage.decode_state_o\[238\] i_decode_stage.decode_state_o\[239\]
+ _0465_ _0427_ _0408_ VGND VGND VPWR VPWR _1047_ sky130_fd_sc_hd__a221o_1
X_3066_ i_exec_stage.data_fwd_o\[20\] _0726_ _0977_ VGND VGND VPWR VPWR _0978_ sky130_fd_sc_hd__o21ai_4
XFILLER_0_18_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3968_ net32 net18 i_exec_stage.exec_state_o\[8\] VGND VGND VPWR VPWR _1817_ sky130_fd_sc_hd__mux2_1
X_2919_ _0832_ _0833_ VGND VGND VPWR VPWR _0834_ sky130_fd_sc_hd__nor2b_2
X_3899_ _1773_ VGND VGND VPWR VPWR _1774_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_45_375 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_5_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_95_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_55_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_48_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_75_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_75_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4940_ clknet_leaf_18_clk_i _0120_ net296 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[147\]
+ sky130_fd_sc_hd__dfrtp_4
X_4871_ clknet_leaf_22_clk_i _0051_ net288 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[55\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_86_286 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3822_ _1692_ _1696_ _1702_ VGND VGND VPWR VPWR _1703_ sky130_fd_sc_hd__or3b_1
X_3753_ _1492_ _1563_ _1634_ _1636_ VGND VGND VPWR VPWR _1637_ sky130_fd_sc_hd__o31a_1
X_3684_ _0707_ _1415_ _0448_ VGND VGND VPWR VPWR _1572_ sky130_fd_sc_hd__a21o_1
X_2704_ i_exec_stage.data_fwd_o\[12\] _0352_ _0355_ _0357_ VGND VGND VPWR VPWR _0629_
+ sky130_fd_sc_hd__or4_1
XFILLER_0_40_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput201 net201 VGND VGND VPWR VPWR imem_addr_o[10] sky130_fd_sc_hd__buf_2
X_2635_ _0346_ i_decode_stage.decode_state_o\[130\] VGND VGND VPWR VPWR _0567_ sky130_fd_sc_hd__or2b_1
X_5354_ net48 VGND VGND VPWR VPWR net239 sky130_fd_sc_hd__clkbuf_1
Xoutput234 net234 VGND VGND VPWR VPWR rf_port1_reg_o[2] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_2_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput212 net212 VGND VGND VPWR VPWR imem_addr_o[20] sky130_fd_sc_hd__buf_2
Xoutput223 net223 VGND VGND VPWR VPWR imem_addr_o[30] sky130_fd_sc_hd__buf_2
Xoutput256 net256 VGND VGND VPWR VPWR rf_wr_data_o[22] sky130_fd_sc_hd__buf_2
Xoutput245 net245 VGND VGND VPWR VPWR rf_wr_data_o[12] sky130_fd_sc_hd__clkbuf_4
Xoutput267 net267 VGND VGND VPWR VPWR rf_wr_data_o[3] sky130_fd_sc_hd__clkbuf_4
X_2566_ _0451_ _0505_ _0506_ _0492_ VGND VGND VPWR VPWR _0507_ sky130_fd_sc_hd__a2bb2o_4
XFILLER_0_49_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4305_ net37 _2037_ net39 net61 VGND VGND VPWR VPWR _2038_ sky130_fd_sc_hd__a31o_1
Xoutput278 net278 VGND VGND VPWR VPWR rf_wr_reg_o[3] sky130_fd_sc_hd__buf_2
X_2497_ _0338_ i_decode_stage.decode_state_o\[140\] i_decode_stage.decode_state_o\[44\]
+ _0339_ _2333_ VGND VGND VPWR VPWR _0445_ sky130_fd_sc_hd__a221o_1
X_5285_ clknet_leaf_4_clk_i _0284_ VGND VGND VPWR VPWR i_exec_stage.data_fwd_o\[19\]
+ sky130_fd_sc_hd__dfxtp_1
X_4236_ i_decode_stage.decode_state_o\[61\] i_decode_stage.fetch_state_i\[53\] _1982_
+ VGND VGND VPWR VPWR _1997_ sky130_fd_sc_hd__mux2_1
X_4167_ _1961_ VGND VGND VPWR VPWR _0023_ sky130_fd_sc_hd__clkbuf_1
X_3118_ i_exec_stage.data_fwd_o\[32\] _0726_ _1029_ VGND VGND VPWR VPWR _1030_ sky130_fd_sc_hd__o21ai_4
XFILLER_0_65_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_65_93 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4098_ _1864_ _1915_ _1858_ VGND VGND VPWR VPWR _1916_ sky130_fd_sc_hd__or3b_1
X_3049_ i_exec_stage.data_fwd_o\[18\] _0726_ _0960_ VGND VGND VPWR VPWR _0961_ sky130_fd_sc_hd__o21ai_4
XFILLER_0_77_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_492 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_60_197 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_68_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_71_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_101_57 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_101_35 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_12_507 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2420_ i_decode_stage.decode_state_o\[123\] net279 VGND VGND VPWR VPWR _0372_ sky130_fd_sc_hd__or2b_1
XFILLER_0_10_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_10_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_24_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2351_ _2337_ _2338_ _2339_ _2340_ VGND VGND VPWR VPWR _2341_ sky130_fd_sc_hd__nor4b_4
X_5070_ clknet_leaf_43_clk_i i_decode_stage.decode_state_o\[14\] net280 VGND VGND
+ VPWR VPWR i_exec_stage.exec_state_o\[45\] sky130_fd_sc_hd__dfrtp_1
X_4021_ _1838_ VGND VGND VPWR VPWR _1839_ sky130_fd_sc_hd__buf_12
X_4923_ clknet_leaf_32_clk_i _0103_ net286 VGND VGND VPWR VPWR net206 sky130_fd_sc_hd__dfrtp_4
XFILLER_0_19_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4854_ clknet_leaf_25_clk_i _0034_ net289 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[38\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_34_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4785_ i_exec_stage.data_fwd_o\[23\] net144 _1838_ VGND VGND VPWR VPWR _2315_ sky130_fd_sc_hd__mux2_1
X_3805_ _1129_ _1369_ _1678_ _1686_ VGND VGND VPWR VPWR _1687_ sky130_fd_sc_hd__a211oi_1
XFILLER_0_27_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_55_492 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3736_ _1598_ _1599_ _0819_ _0818_ VGND VGND VPWR VPWR _1621_ sky130_fd_sc_hd__a211o_1
XFILLER_0_42_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_70_462 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3667_ _1041_ _1194_ _0713_ VGND VGND VPWR VPWR _1556_ sky130_fd_sc_hd__o21a_1
XFILLER_0_42_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_100_214 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_30_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2618_ i_mem_slice_stage.mem_state_o\[99\] _0452_ _0552_ _0455_ VGND VGND VPWR VPWR
+ net262 sky130_fd_sc_hd__a22o_1
X_3598_ _0928_ _0935_ _1364_ _1489_ VGND VGND VPWR VPWR _1490_ sky130_fd_sc_hd__and4_1
X_2549_ i_decode_stage.decode_state_o\[100\] _0491_ _0347_ VGND VGND VPWR VPWR _0492_
+ sky130_fd_sc_hd__a21oi_4
X_5268_ clknet_leaf_37_clk_i _0267_ VGND VGND VPWR VPWR i_exec_stage.data_fwd_o\[2\]
+ sky130_fd_sc_hd__dfxtp_1
X_4219_ _1988_ VGND VGND VPWR VPWR _0048_ sky130_fd_sc_hd__clkbuf_1
X_5199_ clknet_leaf_38_clk_i net395 net131 VGND VGND VPWR VPWR net278 sky130_fd_sc_hd__dfrtp_4
XFILLER_0_65_212 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_38_459 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_18_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_18_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_0_209 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_21_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout280 net281 VGND VGND VPWR VPWR net280 sky130_fd_sc_hd__buf_12
Xfanout291 net131 VGND VGND VPWR VPWR net291 sky130_fd_sc_hd__buf_8
XFILLER_0_88_348 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_96_392 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_8_309 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_29_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4570_ i_decode_stage.reg_meta_o\[56\] net70 _2207_ VGND VGND VPWR VPWR _2213_ sky130_fd_sc_hd__mux2_1
XFILLER_0_21_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_71_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_71_259 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3521_ _1087_ _1218_ _1222_ _1332_ _1416_ VGND VGND VPWR VPWR _1417_ sky130_fd_sc_hd__a221o_1
XFILLER_0_52_440 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_24_197 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3452_ _0650_ _0919_ VGND VGND VPWR VPWR _1351_ sky130_fd_sc_hd__nor2_1
X_3383_ _1282_ _1284_ _0523_ VGND VGND VPWR VPWR _1285_ sky130_fd_sc_hd__mux2_1
X_2403_ i_decode_stage.decode_state_o\[123\] i_exec_stage.data_fwd_o\[37\] VGND VGND
+ VPWR VPWR _0356_ sky130_fd_sc_hd__xnor2_1
X_5122_ clknet_leaf_14_clk_i i_mem_slice_stage.pre_data\[25\] net294 VGND VGND VPWR
+ VPWR i_mem_slice_stage.mem_state_o\[25\] sky130_fd_sc_hd__dfrtp_1
X_5053_ clknet_leaf_15_clk_i net143 net293 VGND VGND VPWR VPWR i_exec_stage.exec_state_o\[28\]
+ sky130_fd_sc_hd__dfrtp_1
X_4004_ net8 _1829_ _1837_ VGND VGND VPWR VPWR i_mem_slice_stage.pre_data\[16\] sky130_fd_sc_hd__a21o_1
XFILLER_0_46_62 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_79_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_94_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4906_ clknet_2_3__leaf_clk_i _0086_ net296 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[240\]
+ sky130_fd_sc_hd__dfrtp_1
X_4837_ clknet_leaf_31_clk_i _0017_ net285 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[21\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_28_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_62_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4768_ _2306_ VGND VGND VPWR VPWR _0279_ sky130_fd_sc_hd__clkbuf_1
X_3719_ _1604_ VGND VGND VPWR VPWR _1605_ sky130_fd_sc_hd__inv_2
X_4699_ net203 i_decode_stage.fetch_state_i\[44\] _1967_ VGND VGND VPWR VPWR _2272_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_101_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold22 i_exec_stage.exec_state_o\[60\] VGND VGND VPWR VPWR net359 sky130_fd_sc_hd__clkdlybuf4s25_1
Xhold11 i_exec_stage.exec_state_o\[61\] VGND VGND VPWR VPWR net348 sky130_fd_sc_hd__clkdlybuf4s25_1
Xhold33 i_exec_stage.exec_state_o\[9\] VGND VGND VPWR VPWR net370 sky130_fd_sc_hd__clkdlybuf4s25_1
Xhold44 i_exec_stage.exec_state_o\[48\] VGND VGND VPWR VPWR net381 sky130_fd_sc_hd__clkdlybuf4s25_1
Xhold55 i_exec_stage.exec_state_o\[64\] VGND VGND VPWR VPWR net392 sky130_fd_sc_hd__clkdlybuf4s25_1
Xhold77 i_exec_stage.exec_state_o\[37\] VGND VGND VPWR VPWR net414 sky130_fd_sc_hd__clkdlybuf4s25_1
Xhold66 i_exec_stage.exec_state_o\[43\] VGND VGND VPWR VPWR net403 sky130_fd_sc_hd__clkdlybuf4s25_1
Xcore_302 VGND VGND VPWR VPWR core_302/HI imem_be_o[2] sky130_fd_sc_hd__conb_1
Xcore_313 VGND VGND VPWR VPWR core_313/HI imem_wdata_o[9] sky130_fd_sc_hd__conb_1
Xcore_324 VGND VGND VPWR VPWR core_324/HI imem_wdata_o[20] sky130_fd_sc_hd__conb_1
Xcore_335 VGND VGND VPWR VPWR core_335/HI imem_wdata_o[31] sky130_fd_sc_hd__conb_1
XFILLER_0_93_340 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_26_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_8 _0596_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_34_495 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_61_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_329 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_318 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_307 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_40_clk_i clknet_2_0__leaf_clk_i VGND VGND VPWR VPWR clknet_leaf_40_clk_i
+ sky130_fd_sc_hd__clkbuf_16
X_2952_ _2333_ net194 _0865_ VGND VGND VPWR VPWR _0866_ sky130_fd_sc_hd__a21oi_2
XTAP_1090 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_8_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2883_ _0484_ _0796_ VGND VGND VPWR VPWR _0798_ sky130_fd_sc_hd__and2_1
X_4622_ net200 i_exec_stage.alu_out\[0\] _2042_ VGND VGND VPWR VPWR _2239_ sky130_fd_sc_hd__mux2_1
X_4553_ i_decode_stage.reg_meta_o\[48\] net93 _2179_ VGND VGND VPWR VPWR _2204_ sky130_fd_sc_hd__mux2_1
XFILLER_0_25_473 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_4_389 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4484_ i_decode_stage.reg_meta_o\[14\] net129 _2012_ VGND VGND VPWR VPWR _2169_ sky130_fd_sc_hd__mux2_1
X_3504_ _0448_ _1394_ _1400_ VGND VGND VPWR VPWR _1401_ sky130_fd_sc_hd__o21ba_1
X_3435_ _0448_ _1324_ _1331_ _1334_ VGND VGND VPWR VPWR _1335_ sky130_fd_sc_hd__a22o_1
XFILLER_0_40_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3366_ _0413_ _1267_ VGND VGND VPWR VPWR _1268_ sky130_fd_sc_hd__nor2_1
XTAP_830 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_841 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_852 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5105_ clknet_leaf_13_clk_i i_mem_slice_stage.pre_data\[8\] net293 VGND VGND VPWR
+ VPWR i_mem_slice_stage.mem_state_o\[8\] sky130_fd_sc_hd__dfrtp_1
X_3297_ _0707_ _0713_ _1194_ _1201_ _1163_ VGND VGND VPWR VPWR _1202_ sky130_fd_sc_hd__o32a_1
XTAP_885 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_863 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_874 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5036_ clknet_leaf_12_clk_i net156 net293 VGND VGND VPWR VPWR i_exec_stage.exec_state_o\[11\]
+ sky130_fd_sc_hd__dfrtp_1
XTAP_896 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_94_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_7_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_90_365 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_43_281 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xinput101 rf_rs2_i[11] VGND VGND VPWR VPWR net101 sky130_fd_sc_hd__clkbuf_1
Xinput112 rf_rs2_i[21] VGND VGND VPWR VPWR net112 sky130_fd_sc_hd__clkbuf_1
Xinput123 rf_rs2_i[31] VGND VGND VPWR VPWR net123 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_98_421 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_58_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_58_329 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_85_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_66_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_337 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_22_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3220_ _0590_ _1125_ VGND VGND VPWR VPWR _1126_ sky130_fd_sc_hd__nand2_1
X_3151_ _0343_ _0725_ VGND VGND VPWR VPWR _1063_ sky130_fd_sc_hd__nor2_1
XFILLER_0_27_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3082_ _0964_ _0965_ VGND VGND VPWR VPWR _0994_ sky130_fd_sc_hd__or2_1
X_3984_ net15 _1815_ _1827_ _1810_ VGND VGND VPWR VPWR _1828_ sky130_fd_sc_hd__a22o_1
XFILLER_0_17_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_17_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2935_ _0617_ _0849_ VGND VGND VPWR VPWR _0850_ sky130_fd_sc_hd__nand2_1
XFILLER_0_72_321 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2866_ _0779_ _0780_ VGND VGND VPWR VPWR _0781_ sky130_fd_sc_hd__or2_1
XFILLER_0_72_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4605_ _2230_ VGND VGND VPWR VPWR _0192_ sky130_fd_sc_hd__clkbuf_1
X_2797_ _0525_ _0715_ VGND VGND VPWR VPWR _0716_ sky130_fd_sc_hd__or2_1
XFILLER_0_4_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_25_281 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4536_ _2195_ VGND VGND VPWR VPWR _0158_ sky130_fd_sc_hd__clkbuf_1
X_4467_ _2160_ VGND VGND VPWR VPWR _0124_ sky130_fd_sc_hd__clkbuf_1
X_4398_ net212 _1927_ VGND VGND VPWR VPWR _2108_ sky130_fd_sc_hd__and2_1
X_3418_ _0897_ _0904_ _0913_ VGND VGND VPWR VPWR _1318_ sky130_fd_sc_hd__and3_1
X_3349_ _0582_ _1251_ VGND VGND VPWR VPWR _1252_ sky130_fd_sc_hd__or2_1
XTAP_660 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_671 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_682 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_693 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5019_ clknet_leaf_39_clk_i _0199_ net282 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[123\]
+ sky130_fd_sc_hd__dfrtp_2
XFILLER_0_48_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_63_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_51_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_284 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_101_183 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2720_ i_mem_slice_stage.mem_state_o\[48\] i_mem_slice_stage.mem_state_o\[9\] _0453_
+ VGND VGND VPWR VPWR _0644_ sky130_fd_sc_hd__mux2_2
XFILLER_0_81_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2651_ _0384_ net192 _0580_ VGND VGND VPWR VPWR _0581_ sky130_fd_sc_hd__o21a_1
XFILLER_0_54_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_54_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2582_ i_decode_stage.decode_state_o\[126\] _0337_ i_decode_stage.decode_state_o\[232\]
+ _0520_ VGND VGND VPWR VPWR _0521_ sky130_fd_sc_hd__a31oi_4
X_4321_ _0722_ _1924_ VGND VGND VPWR VPWR _2048_ sky130_fd_sc_hd__nand2_4
XFILLER_0_10_457 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4252_ i_decode_stage.decode_state_o\[69\] i_decode_stage.fetch_state_i\[61\] _1982_
+ VGND VGND VPWR VPWR _2005_ sky130_fd_sc_hd__mux2_1
XFILLER_0_38_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3203_ _1109_ _1111_ _1105_ VGND VGND VPWR VPWR net164 sky130_fd_sc_hd__a21oi_1
X_4183_ i_decode_stage.fetch_state_i\[27\] i_decode_stage.decode_state_o\[35\] _1967_
+ VGND VGND VPWR VPWR _1970_ sky130_fd_sc_hd__mux2_1
XFILLER_0_38_85 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3134_ _0345_ _0419_ _0417_ VGND VGND VPWR VPWR _1046_ sky130_fd_sc_hd__o21a_1
X_3065_ i_decode_stage.reg_meta_o\[25\] _0727_ _0386_ _0976_ VGND VGND VPWR VPWR _0977_
+ sky130_fd_sc_hd__a211o_1
XFILLER_0_89_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_9_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3967_ net1 _1809_ _1816_ VGND VGND VPWR VPWR i_mem_slice_stage.pre_data\[0\] sky130_fd_sc_hd__a21o_1
XFILLER_0_45_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2918_ _0640_ _0831_ VGND VGND VPWR VPWR _0833_ sky130_fd_sc_hd__nand2_1
X_3898_ i_decode_stage.decode_state_o\[0\] _0601_ VGND VGND VPWR VPWR _1773_ sky130_fd_sc_hd__or2_1
XFILLER_0_33_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_45_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_5_473 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2849_ _0762_ _0763_ VGND VGND VPWR VPWR _0764_ sky130_fd_sc_hd__nor2b_2
X_4519_ i_decode_stage.reg_meta_o\[31\] net116 _2179_ VGND VGND VPWR VPWR _2187_ sky130_fd_sc_hd__mux2_1
XTAP_490 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_36_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_51_357 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_59_413 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_24_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4870_ clknet_leaf_29_clk_i _0050_ net291 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[54\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_24_54 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3821_ _0707_ _1554_ _1701_ _0713_ VGND VGND VPWR VPWR _1702_ sky130_fd_sc_hd__a211o_1
XFILLER_0_86_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_15_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_40_42 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3752_ _0790_ _1635_ _1634_ _1565_ VGND VGND VPWR VPWR _1636_ sky130_fd_sc_hd__o2bb2a_1
X_3683_ _1497_ _1570_ _0660_ VGND VGND VPWR VPWR _1571_ sky130_fd_sc_hd__mux2_1
X_2703_ _0376_ _0377_ _0378_ i_decode_stage.reg_meta_o\[55\] VGND VGND VPWR VPWR _0628_
+ sky130_fd_sc_hd__o31a_1
XFILLER_0_40_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_421 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2634_ i_exec_stage.data_fwd_o\[27\] _0565_ _0460_ VGND VGND VPWR VPWR _0566_ sky130_fd_sc_hd__mux2_2
Xoutput202 net202 VGND VGND VPWR VPWR imem_addr_o[11] sky130_fd_sc_hd__buf_2
X_5353_ net47 VGND VGND VPWR VPWR net238 sky130_fd_sc_hd__clkbuf_1
Xoutput235 net235 VGND VGND VPWR VPWR rf_port1_reg_o[3] sky130_fd_sc_hd__clkbuf_4
Xoutput213 net213 VGND VGND VPWR VPWR imem_addr_o[21] sky130_fd_sc_hd__buf_2
Xoutput224 net224 VGND VGND VPWR VPWR imem_addr_o[31] sky130_fd_sc_hd__buf_2
X_2565_ i_decode_stage.decode_state_o\[122\] _0493_ VGND VGND VPWR VPWR _0506_ sky130_fd_sc_hd__nand2_1
Xoutput257 net257 VGND VGND VPWR VPWR rf_wr_data_o[23] sky130_fd_sc_hd__buf_2
Xoutput246 net246 VGND VGND VPWR VPWR rf_wr_data_o[13] sky130_fd_sc_hd__buf_2
Xoutput268 net268 VGND VGND VPWR VPWR rf_wr_data_o[4] sky130_fd_sc_hd__clkbuf_4
X_4304_ net38 VGND VGND VPWR VPWR _2037_ sky130_fd_sc_hd__inv_2
Xoutput279 net279 VGND VGND VPWR VPWR rf_wr_reg_o[4] sky130_fd_sc_hd__clkbuf_4
X_5284_ clknet_leaf_3_clk_i _0283_ VGND VGND VPWR VPWR i_exec_stage.data_fwd_o\[18\]
+ sky130_fd_sc_hd__dfxtp_1
X_2496_ _0444_ VGND VGND VPWR VPWR net193 sky130_fd_sc_hd__clkinv_2
X_4235_ _1996_ VGND VGND VPWR VPWR _0056_ sky130_fd_sc_hd__clkbuf_1
X_4166_ i_decode_stage.fetch_state_i\[19\] i_decode_stage.decode_state_o\[27\] _1936_
+ VGND VGND VPWR VPWR _1961_ sky130_fd_sc_hd__mux2_1
X_3117_ i_decode_stage.reg_meta_o\[37\] _0727_ _0386_ _1028_ VGND VGND VPWR VPWR _1029_
+ sky130_fd_sc_hd__a211o_1
X_4097_ _0336_ _0381_ VGND VGND VPWR VPWR _1915_ sky130_fd_sc_hd__and2_1
XFILLER_0_77_210 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3048_ i_decode_stage.reg_meta_o\[23\] _0727_ _0386_ _0959_ VGND VGND VPWR VPWR _0960_
+ sky130_fd_sc_hd__a211o_1
XFILLER_0_81_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_65_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4999_ clknet_2_0__leaf_clk_i _0179_ net281 VGND VGND VPWR VPWR i_decode_stage.reg_meta_o\[60\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_18_365 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_33_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_33_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_68_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_91_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_3_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_3_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_36_184 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_101_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_69 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_86_49 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2350_ i_fwd_unit.mem_stage_i\[0\] i_fwd_unit.mem_stage_i\[39\] i_decode_stage.reg_meta_o\[43\]
+ VGND VGND VPWR VPWR _2340_ sky130_fd_sc_hd__and3_1
X_4020_ net292 VGND VGND VPWR VPWR _1838_ sky130_fd_sc_hd__buf_8
X_4922_ clknet_leaf_29_clk_i _0102_ net285 VGND VGND VPWR VPWR net205 sky130_fd_sc_hd__dfrtp_2
XFILLER_0_59_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4853_ clknet_leaf_27_clk_i _0033_ net289 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[37\]
+ sky130_fd_sc_hd__dfrtp_1
X_4784_ _2314_ VGND VGND VPWR VPWR _0287_ sky130_fd_sc_hd__clkbuf_1
X_3804_ _1144_ _0764_ _1683_ _1204_ _1685_ VGND VGND VPWR VPWR _1686_ sky130_fd_sc_hd__a221o_1
XFILLER_0_82_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_15_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3735_ _1598_ _1599_ _0819_ VGND VGND VPWR VPWR _1620_ sky130_fd_sc_hd__a21oi_1
X_3666_ _1392_ _1554_ _0590_ VGND VGND VPWR VPWR _1555_ sky130_fd_sc_hd__mux2_1
XFILLER_0_30_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_70_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2617_ i_mem_slice_stage.mem_state_o\[67\] i_mem_slice_stage.mem_state_o\[28\] _0453_
+ VGND VGND VPWR VPWR _0552_ sky130_fd_sc_hd__mux2_2
X_3597_ _0852_ _1455_ _1444_ VGND VGND VPWR VPWR _1489_ sky130_fd_sc_hd__and3b_1
XFILLER_0_62_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2548_ _0346_ i_decode_stage.decode_state_o\[234\] VGND VGND VPWR VPWR _0491_ sky130_fd_sc_hd__and2_2
X_5267_ clknet_leaf_5_clk_i _0266_ VGND VGND VPWR VPWR i_exec_stage.data_fwd_o\[1\]
+ sky130_fd_sc_hd__dfxtp_1
X_2479_ i_decode_stage.decode_state_o\[238\] _0408_ VGND VGND VPWR VPWR _0429_ sky130_fd_sc_hd__nor2_2
X_4218_ i_decode_stage.decode_state_o\[52\] i_decode_stage.fetch_state_i\[44\] _1982_
+ VGND VGND VPWR VPWR _1988_ sky130_fd_sc_hd__mux2_1
X_5198_ clknet_leaf_40_clk_i net344 net282 VGND VGND VPWR VPWR net277 sky130_fd_sc_hd__dfrtp_4
X_4149_ _1952_ VGND VGND VPWR VPWR _0014_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_97_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_92_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_65_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xfanout292 net297 VGND VGND VPWR VPWR net292 sky130_fd_sc_hd__buf_12
Xfanout281 net131 VGND VGND VPWR VPWR net281 sky130_fd_sc_hd__buf_12
XFILLER_0_88_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_88_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_24_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3520_ _1208_ _1412_ _1415_ _1281_ VGND VGND VPWR VPWR _1416_ sky130_fd_sc_hd__a22o_1
XFILLER_0_52_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_21_99 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_97_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3451_ _0588_ _1348_ _1349_ _1216_ VGND VGND VPWR VPWR _1350_ sky130_fd_sc_hd__a2bb2o_1
X_3382_ _1206_ _1283_ _0421_ VGND VGND VPWR VPWR _1284_ sky130_fd_sc_hd__mux2_1
X_2402_ _0353_ i_exec_stage.data_fwd_o\[33\] i_decode_stage.decode_state_o\[122\]
+ _0348_ _0354_ VGND VGND VPWR VPWR _0355_ sky130_fd_sc_hd__a221o_4
X_5121_ clknet_leaf_15_clk_i i_mem_slice_stage.pre_data\[24\] net294 VGND VGND VPWR
+ VPWR i_mem_slice_stage.mem_state_o\[24\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_20_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5052_ clknet_leaf_11_clk_i net142 net292 VGND VGND VPWR VPWR i_exec_stage.exec_state_o\[27\]
+ sky130_fd_sc_hd__dfrtp_1
X_4003_ _1836_ VGND VGND VPWR VPWR _1837_ sky130_fd_sc_hd__buf_4
XFILLER_0_46_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_46_85 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_1_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_62_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_87_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_47_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4905_ clknet_leaf_18_clk_i _0085_ net296 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[239\]
+ sky130_fd_sc_hd__dfrtp_4
X_4836_ clknet_leaf_40_clk_i _0016_ net282 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[20\]
+ sky130_fd_sc_hd__dfrtp_1
X_4767_ i_exec_stage.data_fwd_o\[14\] net135 _1839_ VGND VGND VPWR VPWR _2306_ sky130_fd_sc_hd__mux2_1
XFILLER_0_43_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3718_ _1540_ _1603_ _0523_ VGND VGND VPWR VPWR _1604_ sky130_fd_sc_hd__mux2_1
X_4698_ _2271_ VGND VGND VPWR VPWR _0244_ sky130_fd_sc_hd__clkbuf_1
X_3649_ _0421_ _1496_ VGND VGND VPWR VPWR _1539_ sky130_fd_sc_hd__nor2_1
XFILLER_0_11_393 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xhold23 i_exec_stage.exec_state_o\[29\] VGND VGND VPWR VPWR net360 sky130_fd_sc_hd__clkdlybuf4s25_1
Xhold12 i_decode_stage.decode_state_o\[11\] VGND VGND VPWR VPWR net349 sky130_fd_sc_hd__clkdlybuf4s25_1
Xhold56 i_exec_stage.exec_state_o\[30\] VGND VGND VPWR VPWR net393 sky130_fd_sc_hd__clkdlybuf4s25_1
Xhold34 i_exec_stage.exec_state_o\[11\] VGND VGND VPWR VPWR net371 sky130_fd_sc_hd__clkdlybuf4s25_1
Xhold45 i_exec_stage.exec_state_o\[53\] VGND VGND VPWR VPWR net382 sky130_fd_sc_hd__clkdlybuf4s25_1
Xhold67 i_exec_stage.exec_state_o\[42\] VGND VGND VPWR VPWR net404 sky130_fd_sc_hd__clkdlybuf4s25_1
XFILLER_0_97_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_97_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xcore_336 VGND VGND VPWR VPWR core_336/HI imem_we_o sky130_fd_sc_hd__conb_1
Xcore_303 VGND VGND VPWR VPWR core_303/HI imem_be_o[3] sky130_fd_sc_hd__conb_1
Xcore_314 VGND VGND VPWR VPWR core_314/HI imem_wdata_o[10] sky130_fd_sc_hd__conb_1
Xcore_325 VGND VGND VPWR VPWR core_325/HI imem_wdata_o[21] sky130_fd_sc_hd__conb_1
XFILLER_0_38_213 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_66_500 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_93_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_9 _0605_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_319 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_308 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_69_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2951_ i_decode_stage.decode_state_o\[45\] _0339_ _0751_ i_decode_stage.decode_state_o\[129\]
+ VGND VGND VPWR VPWR _0865_ sky130_fd_sc_hd__a22o_1
XFILLER_0_69_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_1091 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1080 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_32_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4621_ i_decode_stage.reg_meta_o\[81\] _1928_ _2019_ _2030_ VGND VGND VPWR VPWR _0200_
+ sky130_fd_sc_hd__a22o_1
X_2882_ _0484_ _0796_ VGND VGND VPWR VPWR _0797_ sky130_fd_sc_hd__nor2_1
XFILLER_0_25_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4552_ _2203_ VGND VGND VPWR VPWR _0166_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_25_485 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4483_ _2168_ VGND VGND VPWR VPWR _0132_ sky130_fd_sc_hd__clkbuf_1
X_3503_ _0949_ _1395_ _1398_ _0448_ _1399_ VGND VGND VPWR VPWR _1400_ sky130_fd_sc_hd__a221o_1
X_3434_ _1060_ _1087_ _1333_ VGND VGND VPWR VPWR _1334_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_40_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_820 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_831 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_842 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_853 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3365_ _0677_ _0880_ VGND VGND VPWR VPWR _1267_ sky130_fd_sc_hd__nor2_1
X_5104_ clknet_leaf_13_clk_i i_mem_slice_stage.pre_data\[7\] net294 VGND VGND VPWR
+ VPWR i_mem_slice_stage.mem_state_o\[7\] sky130_fd_sc_hd__dfrtp_1
X_3296_ _1195_ _1196_ _1200_ VGND VGND VPWR VPWR _1201_ sky130_fd_sc_hd__a21oi_1
XTAP_886 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_864 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_875 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5035_ clknet_leaf_12_clk_i net155 net293 VGND VGND VPWR VPWR i_exec_stage.exec_state_o\[10\]
+ sky130_fd_sc_hd__dfrtp_1
XTAP_897 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_63_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4819_ i_decode_stage.valid_i _1840_ _2047_ VGND VGND VPWR VPWR _0305_ sky130_fd_sc_hd__o21a_1
XFILLER_0_7_184 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_90_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_293 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_101_321 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_101_365 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xinput102 rf_rs2_i[12] VGND VGND VPWR VPWR net102 sky130_fd_sc_hd__clkbuf_1
Xinput124 rf_rs2_i[3] VGND VGND VPWR VPWR net124 sky130_fd_sc_hd__clkbuf_1
Xinput113 rf_rs2_i[22] VGND VGND VPWR VPWR net113 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_98_433 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_98_400 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_98_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_81_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_349 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_22_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3150_ _0343_ _0545_ _1061_ VGND VGND VPWR VPWR _1062_ sky130_fd_sc_hd__o21ai_1
X_3081_ _0966_ _0975_ _0992_ VGND VGND VPWR VPWR _0993_ sky130_fd_sc_hd__or3b_1
XFILLER_0_76_116 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_9_405 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3983_ net6 net24 i_exec_stage.exec_state_o\[8\] VGND VGND VPWR VPWR _1827_ sky130_fd_sc_hd__mux2_1
XFILLER_0_9_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2934_ _2333_ _0846_ _0847_ _0848_ VGND VGND VPWR VPWR _0849_ sky130_fd_sc_hd__a31o_1
XFILLER_0_94_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2865_ _0470_ _0778_ VGND VGND VPWR VPWR _0780_ sky130_fd_sc_hd__and2_1
XFILLER_0_72_333 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4604_ i_decode_stage.reg_meta_o\[73\] net88 _2207_ VGND VGND VPWR VPWR _2230_ sky130_fd_sc_hd__mux2_1
X_2796_ _0540_ _0714_ VGND VGND VPWR VPWR _0715_ sky130_fd_sc_hd__or2_1
XFILLER_0_25_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4535_ i_decode_stage.decode_state_o\[125\] net47 _2179_ VGND VGND VPWR VPWR _2195_
+ sky130_fd_sc_hd__mux2_1
X_4466_ net36 i_decode_stage.decode_state_o\[140\] _1967_ VGND VGND VPWR VPWR _2160_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_40_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4397_ _2105_ _2106_ VGND VGND VPWR VPWR _2107_ sky130_fd_sc_hd__nor2_1
X_3417_ _0897_ _0904_ _0913_ VGND VGND VPWR VPWR _1317_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_68_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3348_ _0525_ _0487_ _1250_ VGND VGND VPWR VPWR _1251_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_0_393 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_650 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_661 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_672 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_683 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_694 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3279_ _0590_ _1183_ VGND VGND VPWR VPWR _1184_ sky130_fd_sc_hd__nand2_1
X_5018_ clknet_leaf_40_clk_i _0198_ net282 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[122\]
+ sky130_fd_sc_hd__dfrtp_4
XFILLER_0_95_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_48_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_366 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_101_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_98_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_13_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_6_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_89_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_81_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2650_ i_decode_stage.decode_state_o\[127\] _0337_ i_decode_stage.decode_state_o\[232\]
+ _0579_ VGND VGND VPWR VPWR _0580_ sky130_fd_sc_hd__a31o_2
XFILLER_0_54_377 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2581_ _0338_ i_decode_stage.decode_state_o\[138\] i_decode_stage.decode_state_o\[42\]
+ _0339_ _2333_ VGND VGND VPWR VPWR _0520_ sky130_fd_sc_hd__a221o_1
X_4320_ _2042_ VGND VGND VPWR VPWR _2047_ sky130_fd_sc_hd__clkinv_4
XFILLER_0_10_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4251_ _2004_ VGND VGND VPWR VPWR _0064_ sky130_fd_sc_hd__clkbuf_1
X_3202_ i_decode_stage.decode_state_o\[0\] _1110_ i_exec_stage.alu_out\[1\] i_exec_stage.alu_out\[0\]
+ VGND VGND VPWR VPWR _1111_ sky130_fd_sc_hd__or4_1
XFILLER_0_38_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4182_ _1969_ VGND VGND VPWR VPWR _0030_ sky130_fd_sc_hd__clkbuf_1
X_3133_ _1041_ _1044_ VGND VGND VPWR VPWR _1045_ sky130_fd_sc_hd__nor2_1
X_3064_ _2336_ _2341_ net252 VGND VGND VPWR VPWR _0976_ sky130_fd_sc_hd__and3_1
XFILLER_0_54_41 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3966_ _1810_ _1811_ _1815_ net8 VGND VGND VPWR VPWR _1816_ sky130_fd_sc_hd__a22o_1
X_2917_ _0640_ _0831_ VGND VGND VPWR VPWR _0832_ sky130_fd_sc_hd__nor2_2
XFILLER_0_70_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3897_ _0336_ VGND VGND VPWR VPWR net167 sky130_fd_sc_hd__inv_2
XFILLER_0_72_152 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_5_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2848_ _0568_ _0761_ VGND VGND VPWR VPWR _0763_ sky130_fd_sc_hd__nand2_1
XFILLER_0_5_485 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2779_ _0363_ _0369_ _0374_ net264 VGND VGND VPWR VPWR _0698_ sky130_fd_sc_hd__and4_1
X_4518_ _2186_ VGND VGND VPWR VPWR _0149_ sky130_fd_sc_hd__clkbuf_1
X_4449_ net153 _1924_ VGND VGND VPWR VPWR _2149_ sky130_fd_sc_hd__nor2_1
XTAP_480 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_491 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_95_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_55_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_91_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_51_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_59_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_59_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3820_ _0662_ _1699_ _1700_ _0590_ VGND VGND VPWR VPWR _1701_ sky130_fd_sc_hd__o211a_1
XFILLER_0_74_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3751_ _1608_ _1614_ _0789_ _0797_ VGND VGND VPWR VPWR _1635_ sky130_fd_sc_hd__a211o_1
X_2702_ _0363_ _0369_ _0374_ net244 VGND VGND VPWR VPWR _0627_ sky130_fd_sc_hd__and4_1
XFILLER_0_40_54 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3682_ _1569_ VGND VGND VPWR VPWR _1570_ sky130_fd_sc_hd__inv_2
X_2633_ net260 i_decode_stage.reg_meta_o\[70\] _0457_ VGND VGND VPWR VPWR _0565_ sky130_fd_sc_hd__mux2_1
Xoutput203 net203 VGND VGND VPWR VPWR imem_addr_o[12] sky130_fd_sc_hd__clkbuf_4
Xoutput225 net225 VGND VGND VPWR VPWR imem_addr_o[3] sky130_fd_sc_hd__buf_2
X_5352_ net46 VGND VGND VPWR VPWR net237 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_2_433 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xoutput214 net214 VGND VGND VPWR VPWR imem_addr_o[22] sky130_fd_sc_hd__clkbuf_4
X_2564_ i_exec_stage.data_fwd_o\[19\] _0504_ _0460_ VGND VGND VPWR VPWR _0505_ sky130_fd_sc_hd__mux2_1
XFILLER_0_100_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4303_ i_decode_stage.decode_state_o\[238\] _1840_ _2036_ VGND VGND VPWR VPWR _0084_
+ sky130_fd_sc_hd__o21a_1
Xoutput258 net258 VGND VGND VPWR VPWR rf_wr_data_o[24] sky130_fd_sc_hd__buf_2
Xoutput247 net247 VGND VGND VPWR VPWR rf_wr_data_o[14] sky130_fd_sc_hd__buf_2
Xoutput236 net236 VGND VGND VPWR VPWR rf_port1_reg_o[4] sky130_fd_sc_hd__buf_2
XFILLER_0_2_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xoutput269 net269 VGND VGND VPWR VPWR rf_wr_data_o[5] sky130_fd_sc_hd__buf_2
X_2495_ _0439_ _0442_ _0443_ VGND VGND VPWR VPWR _0444_ sky130_fd_sc_hd__o21ai_4
X_5283_ clknet_leaf_4_clk_i _0282_ VGND VGND VPWR VPWR i_exec_stage.data_fwd_o\[17\]
+ sky130_fd_sc_hd__dfxtp_1
X_4234_ i_decode_stage.decode_state_o\[60\] i_decode_stage.fetch_state_i\[52\] _1982_
+ VGND VGND VPWR VPWR _1996_ sky130_fd_sc_hd__mux2_1
XFILLER_0_4_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4165_ _1960_ VGND VGND VPWR VPWR _0022_ sky130_fd_sc_hd__clkbuf_1
X_3116_ _2336_ _2341_ net266 VGND VGND VPWR VPWR _1028_ sky130_fd_sc_hd__and3_1
X_4096_ i_decode_stage.decode_state_o\[241\] i_decode_stage.decode_state_o\[242\]
+ VGND VGND VPWR VPWR _1914_ sky130_fd_sc_hd__nor2_1
XFILLER_0_77_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3047_ _2336_ _2341_ net250 VGND VGND VPWR VPWR _0959_ sky130_fd_sc_hd__and3_1
XFILLER_0_81_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_77_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_77_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_92_214 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4998_ clknet_leaf_41_clk_i _0178_ net281 VGND VGND VPWR VPWR i_decode_stage.reg_meta_o\[59\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_18_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_33_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3949_ _0741_ VGND VGND VPWR VPWR _1803_ sky130_fd_sc_hd__inv_2
XFILLER_0_60_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_260 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_21_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_88_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_68_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_56_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_225 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_36_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_64_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_51_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_59_211 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4921_ clknet_leaf_31_clk_i _0101_ net285 VGND VGND VPWR VPWR net204 sky130_fd_sc_hd__dfrtp_2
X_4852_ clknet_leaf_27_clk_i _0032_ net290 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[36\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_7_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3803_ _1198_ _0762_ _0763_ _1199_ _1684_ VGND VGND VPWR VPWR _1685_ sky130_fd_sc_hd__a221o_1
XFILLER_0_74_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4783_ i_exec_stage.data_fwd_o\[22\] net143 _1838_ VGND VGND VPWR VPWR _2314_ sky130_fd_sc_hd__mux2_1
X_3734_ _0791_ _1618_ VGND VGND VPWR VPWR _1619_ sky130_fd_sc_hd__xnor2_1
X_3665_ _1473_ _1553_ _0660_ VGND VGND VPWR VPWR _1554_ sky130_fd_sc_hd__mux2_1
XFILLER_0_2_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_30_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2616_ _0451_ _0549_ _0462_ _0550_ VGND VGND VPWR VPWR _0551_ sky130_fd_sc_hd__a2bb2o_4
XFILLER_0_70_497 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3596_ _0850_ _0851_ _1455_ _1445_ _1487_ VGND VGND VPWR VPWR _1488_ sky130_fd_sc_hd__a41o_1
X_2547_ i_exec_stage.data_fwd_o\[20\] _0489_ _0460_ VGND VGND VPWR VPWR _0490_ sky130_fd_sc_hd__mux2_1
X_2478_ _0343_ _0427_ VGND VGND VPWR VPWR _0428_ sky130_fd_sc_hd__or2_1
X_5266_ clknet_leaf_35_clk_i _0265_ VGND VGND VPWR VPWR i_exec_stage.data_fwd_o\[0\]
+ sky130_fd_sc_hd__dfxtp_1
X_4217_ _1987_ VGND VGND VPWR VPWR _0047_ sky130_fd_sc_hd__clkbuf_1
X_5197_ clknet_leaf_38_clk_i net407 net131 VGND VGND VPWR VPWR net276 sky130_fd_sc_hd__dfrtp_4
XFILLER_0_97_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4148_ i_decode_stage.fetch_state_i\[10\] i_decode_stage.decode_state_o\[18\] _1936_
+ VGND VGND VPWR VPWR _1952_ sky130_fd_sc_hd__mux2_1
X_4079_ _0530_ _0730_ _0741_ _0554_ VGND VGND VPWR VPWR _1897_ sky130_fd_sc_hd__a22o_1
XFILLER_0_65_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_141 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_33_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout282 net131 VGND VGND VPWR VPWR net282 sky130_fd_sc_hd__buf_12
Xfanout293 net294 VGND VGND VPWR VPWR net293 sky130_fd_sc_hd__buf_12
XFILLER_0_84_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_52_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3450_ _0707_ _0573_ _1322_ VGND VGND VPWR VPWR _1349_ sky130_fd_sc_hd__o21ai_1
X_3381_ _0345_ _0677_ _1093_ VGND VGND VPWR VPWR _1283_ sky130_fd_sc_hd__a21oi_1
X_2401_ i_decode_stage.decode_state_o\[120\] i_exec_stage.data_fwd_o\[34\] VGND VGND
+ VPWR VPWR _0354_ sky130_fd_sc_hd__xor2_1
X_5120_ clknet_leaf_14_clk_i i_mem_slice_stage.pre_data\[23\] net294 VGND VGND VPWR
+ VPWR i_mem_slice_stage.mem_state_o\[23\] sky130_fd_sc_hd__dfrtp_1
X_5051_ clknet_leaf_11_clk_i net141 net292 VGND VGND VPWR VPWR i_exec_stage.exec_state_o\[26\]
+ sky130_fd_sc_hd__dfrtp_1
X_4002_ _1835_ _1813_ _1831_ _1834_ VGND VGND VPWR VPWR _1836_ sky130_fd_sc_hd__a31o_1
XFILLER_0_46_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_94_309 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_1_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4904_ clknet_leaf_18_clk_i _0084_ net297 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[238\]
+ sky130_fd_sc_hd__dfrtp_4
X_4835_ clknet_leaf_30_clk_i _0015_ net285 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[19\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_47_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_15_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4766_ _2305_ VGND VGND VPWR VPWR _0278_ sky130_fd_sc_hd__clkbuf_1
X_3717_ _1568_ _1602_ _0421_ VGND VGND VPWR VPWR _1603_ sky130_fd_sc_hd__mux2_1
X_4697_ net202 i_decode_stage.fetch_state_i\[43\] _1967_ VGND VGND VPWR VPWR _2271_
+ sky130_fd_sc_hd__mux2_1
X_3648_ _0344_ _0507_ _1057_ VGND VGND VPWR VPWR _1538_ sky130_fd_sc_hd__a21o_1
X_3579_ _0344_ _0617_ _0609_ VGND VGND VPWR VPWR _1472_ sky130_fd_sc_hd__a21o_1
Xhold13 i_exec_stage.exec_state_o\[55\] VGND VGND VPWR VPWR net350 sky130_fd_sc_hd__clkdlybuf4s25_1
Xhold35 i_exec_stage.exec_state_o\[50\] VGND VGND VPWR VPWR net372 sky130_fd_sc_hd__clkdlybuf4s25_1
X_5249_ clknet_leaf_32_clk_i _0248_ net287 VGND VGND VPWR VPWR i_decode_stage.fetch_state_i\[47\]
+ sky130_fd_sc_hd__dfrtp_1
Xhold24 i_exec_stage.exec_state_o\[62\] VGND VGND VPWR VPWR net361 sky130_fd_sc_hd__clkdlybuf4s25_1
Xhold46 i_exec_stage.exec_state_o\[13\] VGND VGND VPWR VPWR net383 sky130_fd_sc_hd__clkdlybuf4s25_1
Xhold68 i_exec_stage.exec_state_o\[58\] VGND VGND VPWR VPWR net405 sky130_fd_sc_hd__clkdlybuf4s25_1
Xhold57 i_exec_stage.exec_state_o\[23\] VGND VGND VPWR VPWR net394 sky130_fd_sc_hd__clkdlybuf4s25_1
Xcore_304 VGND VGND VPWR VPWR core_304/HI imem_wdata_o[0] sky130_fd_sc_hd__conb_1
Xcore_315 VGND VGND VPWR VPWR core_315/HI imem_wdata_o[11] sky130_fd_sc_hd__conb_1
Xcore_326 VGND VGND VPWR VPWR core_326/HI imem_wdata_o[22] sky130_fd_sc_hd__conb_1
XFILLER_0_97_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xcore_337 VGND VGND VPWR VPWR imem_req_o core_337/LO sky130_fd_sc_hd__conb_1
XFILLER_0_66_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_225 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_38_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_46_280 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_34_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_309 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2950_ _0864_ VGND VGND VPWR VPWR net194 sky130_fd_sc_hd__inv_2
XTAP_1092 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1081 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1070 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2881_ _2333_ _0794_ _0795_ VGND VGND VPWR VPWR _0796_ sky130_fd_sc_hd__a21o_1
X_4620_ _2238_ VGND VGND VPWR VPWR _0199_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_89_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4551_ i_decode_stage.reg_meta_o\[47\] net92 _2179_ VGND VGND VPWR VPWR _2203_ sky130_fd_sc_hd__mux2_1
XFILLER_0_4_336 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_25_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4482_ i_decode_stage.reg_meta_o\[13\] net128 _2012_ VGND VGND VPWR VPWR _2168_ sky130_fd_sc_hd__mux2_1
X_3502_ _1199_ _0951_ _0928_ _1144_ VGND VGND VPWR VPWR _1399_ sky130_fd_sc_hd__a22o_1
X_3433_ _1074_ _0448_ _1332_ _1086_ VGND VGND VPWR VPWR _1333_ sky130_fd_sc_hd__a22o_1
XTAP_810 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5103_ clknet_leaf_13_clk_i i_mem_slice_stage.pre_data\[6\] net293 VGND VGND VPWR
+ VPWR i_mem_slice_stage.mem_state_o\[6\] sky130_fd_sc_hd__dfrtp_1
XTAP_821 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_832 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_843 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3364_ _1158_ _1265_ VGND VGND VPWR VPWR _1266_ sky130_fd_sc_hd__nor2_1
X_3295_ _1149_ _0691_ _1162_ _1198_ _1199_ VGND VGND VPWR VPWR _1200_ sky130_fd_sc_hd__a221o_1
XTAP_854 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_865 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_876 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5034_ clknet_leaf_12_clk_i net152 net293 VGND VGND VPWR VPWR i_exec_stage.exec_state_o\[9\]
+ sky130_fd_sc_hd__dfrtp_1
XTAP_898 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_887 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_18_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_67_309 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_73_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_28_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4818_ _2331_ VGND VGND VPWR VPWR _0304_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_90_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_196 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4749_ i_exec_stage.data_fwd_o\[5\] net156 _1839_ VGND VGND VPWR VPWR _2297_ sky130_fd_sc_hd__mux2_1
XFILLER_0_101_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_3_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_377 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xinput125 rf_rs2_i[4] VGND VGND VPWR VPWR net125 sky130_fd_sc_hd__clkbuf_1
Xinput103 rf_rs2_i[13] VGND VGND VPWR VPWR net103 sky130_fd_sc_hd__clkbuf_1
Xinput114 rf_rs2_i[23] VGND VGND VPWR VPWR net114 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_98_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_98_445 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_98_489 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_58_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_78_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_93_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_81_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_22_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_34_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_22_489 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3080_ _0983_ _0991_ VGND VGND VPWR VPWR _0992_ sky130_fd_sc_hd__and2_1
X_3982_ net28 _1809_ _1826_ VGND VGND VPWR VPWR i_mem_slice_stage.pre_data\[5\] sky130_fd_sc_hd__a21o_1
XFILLER_0_76_128 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_9_417 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_0 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_43_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2933_ i_decode_stage.decode_state_o\[55\] _0339_ _0733_ VGND VGND VPWR VPWR _0848_
+ sky130_fd_sc_hd__a21oi_1
X_2864_ _0470_ _0778_ VGND VGND VPWR VPWR _0779_ sky130_fd_sc_hd__nor2_2
XFILLER_0_72_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2795_ _0428_ _0697_ VGND VGND VPWR VPWR _0714_ sky130_fd_sc_hd__nand2_1
X_4603_ _2229_ VGND VGND VPWR VPWR _0191_ sky130_fd_sc_hd__clkbuf_1
X_4534_ _2194_ VGND VGND VPWR VPWR _0157_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_40_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4465_ _2159_ VGND VGND VPWR VPWR _0123_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_0_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4396_ net212 _2101_ VGND VGND VPWR VPWR _2106_ sky130_fd_sc_hd__nor2_1
XFILLER_0_68_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3416_ _0411_ _1294_ _1309_ _1316_ VGND VGND VPWR VPWR net159 sky130_fd_sc_hd__a211o_4
X_3347_ _0523_ _0571_ VGND VGND VPWR VPWR _1250_ sky130_fd_sc_hd__or2_1
XTAP_640 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_651 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_209 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_662 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_673 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_684 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_695 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3278_ _1181_ _1182_ _0662_ VGND VGND VPWR VPWR _1183_ sky130_fd_sc_hd__mux2_1
XFILLER_0_84_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5017_ clknet_leaf_40_clk_i _0197_ net282 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[121\]
+ sky130_fd_sc_hd__dfrtp_2
XFILLER_0_67_139 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_48_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_36_504 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_31_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_31_264 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_101_141 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_98_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_86_426 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_13_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_39_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_89_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2580_ _0322_ _0515_ _0517_ _0518_ VGND VGND VPWR VPWR _0519_ sky130_fd_sc_hd__a31oi_4
X_4250_ i_decode_stage.decode_state_o\[68\] i_decode_stage.fetch_state_i\[60\] _1982_
+ VGND VGND VPWR VPWR _2004_ sky130_fd_sc_hd__mux2_1
X_3201_ _0601_ VGND VGND VPWR VPWR _1110_ sky130_fd_sc_hd__inv_2
X_4181_ i_decode_stage.fetch_state_i\[26\] i_decode_stage.decode_state_o\[34\] _1967_
+ VGND VGND VPWR VPWR _1969_ sky130_fd_sc_hd__mux2_1
X_3132_ _0660_ _1043_ VGND VGND VPWR VPWR _1044_ sky130_fd_sc_hd__nand2_1
X_3063_ _0974_ VGND VGND VPWR VPWR _0975_ sky130_fd_sc_hd__clkbuf_2
XFILLER_0_89_242 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_54_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_89_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_49_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3965_ _1813_ _1814_ i_exec_stage.exec_state_o\[8\] VGND VGND VPWR VPWR _1815_ sky130_fd_sc_hd__o21a_2
XFILLER_0_9_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_64_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3896_ _0411_ _1759_ _1772_ VGND VGND VPWR VPWR net154 sky130_fd_sc_hd__a21o_4
X_2916_ _2333_ _0829_ _0830_ VGND VGND VPWR VPWR _0831_ sky130_fd_sc_hd__a21o_1
XFILLER_0_45_323 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_70_85 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2847_ _0568_ _0761_ VGND VGND VPWR VPWR _0762_ sky130_fd_sc_hd__nor2_2
XFILLER_0_72_164 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2778_ _0344_ _0404_ VGND VGND VPWR VPWR _0697_ sky130_fd_sc_hd__nand2_1
XFILLER_0_13_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_5_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4517_ i_decode_stage.reg_meta_o\[30\] net115 _2179_ VGND VGND VPWR VPWR _2186_ sky130_fd_sc_hd__mux2_1
X_4448_ net221 _1928_ _2144_ _2148_ VGND VGND VPWR VPWR _0117_ sky130_fd_sc_hd__a22o_1
X_4379_ _2091_ _2092_ VGND VGND VPWR VPWR _2093_ sky130_fd_sc_hd__nor2_1
XTAP_470 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_481 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_492 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_68_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_91_473 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_51_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_74_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3750_ _0818_ _1598_ _0809_ _0817_ VGND VGND VPWR VPWR _1634_ sky130_fd_sc_hd__or4_1
XFILLER_0_6_228 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2701_ i_mem_slice_stage.mem_state_o\[82\] _0452_ _0626_ _0455_ VGND VGND VPWR VPWR
+ net244 sky130_fd_sc_hd__a22o_1
XFILLER_0_54_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3681_ _1538_ _1568_ _0421_ VGND VGND VPWR VPWR _1569_ sky130_fd_sc_hd__mux2_1
XFILLER_0_54_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_2_401 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2632_ i_mem_slice_stage.mem_state_o\[97\] _0452_ _0564_ _0455_ VGND VGND VPWR VPWR
+ net260 sky130_fd_sc_hd__a22o_1
Xoutput204 net204 VGND VGND VPWR VPWR imem_addr_o[13] sky130_fd_sc_hd__buf_2
Xoutput226 net226 VGND VGND VPWR VPWR imem_addr_o[4] sky130_fd_sc_hd__clkbuf_4
X_5351_ net44 VGND VGND VPWR VPWR net236 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_2_445 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xoutput215 net215 VGND VGND VPWR VPWR imem_addr_o[23] sky130_fd_sc_hd__buf_2
X_2563_ net251 i_decode_stage.reg_meta_o\[62\] _0457_ VGND VGND VPWR VPWR _0504_ sky130_fd_sc_hd__mux2_1
X_4302_ net39 _2031_ _2033_ _1928_ VGND VGND VPWR VPWR _2036_ sky130_fd_sc_hd__a211o_1
Xoutput259 net259 VGND VGND VPWR VPWR rf_wr_data_o[25] sky130_fd_sc_hd__buf_2
XFILLER_0_10_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xoutput248 net248 VGND VGND VPWR VPWR rf_wr_data_o[15] sky130_fd_sc_hd__clkbuf_4
Xoutput237 net237 VGND VGND VPWR VPWR rf_port2_reg_o[0] sky130_fd_sc_hd__buf_2
XFILLER_0_2_489 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5282_ clknet_leaf_38_clk_i _0281_ VGND VGND VPWR VPWR i_exec_stage.data_fwd_o\[16\]
+ sky130_fd_sc_hd__dfxtp_1
X_4233_ _1995_ VGND VGND VPWR VPWR _0055_ sky130_fd_sc_hd__clkbuf_1
X_2494_ i_exec_stage.data_fwd_o\[5\] _0322_ VGND VGND VPWR VPWR _0443_ sky130_fd_sc_hd__or2_1
XFILLER_0_57_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_2_3__f_clk_i clknet_0_clk_i VGND VGND VPWR VPWR clknet_2_3__leaf_clk_i sky130_fd_sc_hd__clkbuf_16
X_4164_ i_decode_stage.fetch_state_i\[18\] i_decode_stage.decode_state_o\[26\] _1936_
+ VGND VGND VPWR VPWR _1960_ sky130_fd_sc_hd__mux2_1
X_3115_ _0537_ _1022_ VGND VGND VPWR VPWR _1027_ sky130_fd_sc_hd__or2b_1
XFILLER_0_4_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4095_ _1911_ _1912_ VGND VGND VPWR VPWR _1913_ sky130_fd_sc_hd__nor2_1
X_3046_ _0860_ _0938_ _0957_ VGND VGND VPWR VPWR _0958_ sky130_fd_sc_hd__a21oi_4
XFILLER_0_92_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_18_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4997_ clknet_leaf_44_clk_i _0177_ net281 VGND VGND VPWR VPWR i_decode_stage.reg_meta_o\[58\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_45_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3948_ _0601_ _1802_ _1800_ _1778_ _1779_ VGND VGND VPWR VPWR net186 sky130_fd_sc_hd__a221o_1
XFILLER_0_73_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3879_ _1156_ _1026_ _1745_ _1756_ VGND VGND VPWR VPWR _1757_ sky130_fd_sc_hd__a31o_1
XFILLER_0_5_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_68_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_56_429 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_68_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_83_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_64_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_101_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4920_ clknet_leaf_30_clk_i _0100_ net285 VGND VGND VPWR VPWR net203 sky130_fd_sc_hd__dfrtp_4
XFILLER_0_59_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4851_ clknet_leaf_27_clk_i _0031_ net290 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[35\]
+ sky130_fd_sc_hd__dfrtp_1
X_3802_ _0417_ _0568_ VGND VGND VPWR VPWR _1684_ sky130_fd_sc_hd__nor2_1
X_4782_ _2313_ VGND VGND VPWR VPWR _0286_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_82_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3733_ _0799_ _1615_ _0797_ VGND VGND VPWR VPWR _1618_ sky130_fd_sc_hd__a21oi_1
X_3664_ _1517_ _1552_ _0421_ VGND VGND VPWR VPWR _1553_ sky130_fd_sc_hd__mux2_1
X_2615_ _0346_ i_decode_stage.decode_state_o\[131\] VGND VGND VPWR VPWR _0550_ sky130_fd_sc_hd__or2b_1
X_3595_ _0850_ _1448_ _0851_ VGND VGND VPWR VPWR _1487_ sky130_fd_sc_hd__a21bo_1
X_2546_ net252 i_decode_stage.reg_meta_o\[63\] _0457_ VGND VGND VPWR VPWR _0489_ sky130_fd_sc_hd__mux2_1
X_2477_ _0347_ _0381_ VGND VGND VPWR VPWR _0427_ sky130_fd_sc_hd__and2_1
X_5265_ clknet_leaf_27_clk_i _0264_ net290 VGND VGND VPWR VPWR i_decode_stage.fetch_state_i\[63\]
+ sky130_fd_sc_hd__dfrtp_1
X_4216_ i_decode_stage.decode_state_o\[51\] i_decode_stage.fetch_state_i\[43\] _1982_
+ VGND VGND VPWR VPWR _1987_ sky130_fd_sc_hd__mux2_1
X_5196_ clknet_leaf_40_clk_i net347 net282 VGND VGND VPWR VPWR net275 sky130_fd_sc_hd__dfrtp_4
X_4147_ _1951_ VGND VGND VPWR VPWR _0013_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_97_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_92_61 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4078_ _0468_ _0776_ _1895_ VGND VGND VPWR VPWR _1896_ sky130_fd_sc_hd__o21ai_1
X_3029_ _0843_ _0939_ _0940_ VGND VGND VPWR VPWR _0941_ sky130_fd_sc_hd__a21o_1
XFILLER_0_18_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_65_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_73_281 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_18_197 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_61_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_21_318 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_14_392 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xfanout283 net284 VGND VGND VPWR VPWR net283 sky130_fd_sc_hd__buf_12
Xfanout294 net295 VGND VGND VPWR VPWR net294 sky130_fd_sc_hd__buf_12
XFILLER_0_96_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_4_507 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_21_57 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_24_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_24_178 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2400_ i_decode_stage.decode_state_o\[119\] VGND VGND VPWR VPWR _0353_ sky130_fd_sc_hd__inv_2
X_3380_ _1153_ VGND VGND VPWR VPWR _1282_ sky130_fd_sc_hd__inv_1
X_5050_ clknet_leaf_10_clk_i net140 net292 VGND VGND VPWR VPWR i_exec_stage.exec_state_o\[25\]
+ sky130_fd_sc_hd__dfrtp_1
X_4001_ i_exec_stage.exec_state_o\[2\] VGND VGND VPWR VPWR _1835_ sky130_fd_sc_hd__inv_2
XFILLER_0_46_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4903_ clknet_leaf_18_clk_i _0083_ net297 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[237\]
+ sky130_fd_sc_hd__dfrtp_4
XFILLER_0_75_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4834_ clknet_leaf_40_clk_i _0014_ net282 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[18\]
+ sky130_fd_sc_hd__dfrtp_1
X_4765_ i_exec_stage.data_fwd_o\[13\] net134 _1839_ VGND VGND VPWR VPWR _2305_ sky130_fd_sc_hd__mux2_1
X_3716_ _0344_ _0484_ _1052_ VGND VGND VPWR VPWR _1602_ sky130_fd_sc_hd__a21o_1
XFILLER_0_55_281 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4696_ _2270_ VGND VGND VPWR VPWR _0243_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_70_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3647_ _1457_ VGND VGND VPWR VPWR _1537_ sky130_fd_sc_hd__inv_1
XFILLER_0_30_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_30_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3578_ _0852_ _1469_ VGND VGND VPWR VPWR _1471_ sky130_fd_sc_hd__or2_1
XFILLER_0_11_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2529_ net255 i_decode_stage.reg_meta_o\[65\] _0457_ VGND VGND VPWR VPWR _0474_ sky130_fd_sc_hd__mux2_1
Xhold14 i_exec_stage.exec_state_o\[56\] VGND VGND VPWR VPWR net351 sky130_fd_sc_hd__clkdlybuf4s25_1
Xhold25 i_exec_stage.exec_state_o\[18\] VGND VGND VPWR VPWR net362 sky130_fd_sc_hd__clkdlybuf4s25_1
X_5248_ clknet_leaf_29_clk_i _0247_ net291 VGND VGND VPWR VPWR i_decode_stage.fetch_state_i\[46\]
+ sky130_fd_sc_hd__dfrtp_1
Xhold47 i_exec_stage.exec_state_o\[63\] VGND VGND VPWR VPWR net384 sky130_fd_sc_hd__clkdlybuf4s25_1
Xhold36 i_exec_stage.exec_state_o\[65\] VGND VGND VPWR VPWR net373 sky130_fd_sc_hd__clkdlybuf4s25_1
Xhold58 i_exec_stage.reg_meta_o\[3\] VGND VGND VPWR VPWR net395 sky130_fd_sc_hd__clkdlybuf4s25_1
X_5179_ clknet_leaf_31_clk_i net385 net286 VGND VGND VPWR VPWR i_mem_slice_stage.mem_state_o\[86\]
+ sky130_fd_sc_hd__dfrtp_1
Xhold69 i_decode_stage.decode_state_o\[34\] VGND VGND VPWR VPWR net406 sky130_fd_sc_hd__clkdlybuf4s25_1
XFILLER_0_97_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xcore_305 VGND VGND VPWR VPWR core_305/HI imem_wdata_o[1] sky130_fd_sc_hd__conb_1
Xcore_316 VGND VGND VPWR VPWR core_316/HI imem_wdata_o[12] sky130_fd_sc_hd__conb_1
Xcore_327 VGND VGND VPWR VPWR core_327/HI imem_wdata_o[23] sky130_fd_sc_hd__conb_1
XFILLER_0_93_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_93_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_38_237 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_81_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_473 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_46_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_61_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_61_262 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1082 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_1071 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1060 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2880_ i_decode_stage.decode_state_o\[62\] _0731_ _0733_ VGND VGND VPWR VPWR _0795_
+ sky130_fd_sc_hd__a21oi_1
XTAP_1093 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_4_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4550_ _2202_ VGND VGND VPWR VPWR _0165_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_4_348 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3501_ _0590_ _0594_ _1180_ _1397_ VGND VGND VPWR VPWR _1398_ sky130_fd_sc_hd__a31o_1
X_4481_ _2167_ VGND VGND VPWR VPWR _0131_ sky130_fd_sc_hd__clkbuf_1
X_3432_ _0593_ _0707_ VGND VGND VPWR VPWR _1332_ sky130_fd_sc_hd__nor2_1
XFILLER_0_40_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_800 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3363_ _0881_ _1264_ VGND VGND VPWR VPWR _1265_ sky130_fd_sc_hd__xor2_1
X_5102_ clknet_leaf_13_clk_i i_mem_slice_stage.pre_data\[5\] net293 VGND VGND VPWR
+ VPWR i_mem_slice_stage.mem_state_o\[5\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_20_181 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_811 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_822 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_833 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_844 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3294_ _0418_ _0413_ VGND VGND VPWR VPWR _1199_ sky130_fd_sc_hd__nor2_8
XFILLER_0_57_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_855 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_866 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_877 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5033_ clknet_leaf_13_clk_i i_exec_stage.alu_out\[1\] net293 VGND VGND VPWR VPWR
+ i_exec_stage.exec_state_o\[8\] sky130_fd_sc_hd__dfrtp_4
XTAP_899 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_888 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_32_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4817_ i_exec_stage.data_fwd_o\[39\] i_decode_stage.decode_state_o\[7\] _1838_ VGND
+ VGND VPWR VPWR _2331_ sky130_fd_sc_hd__mux2_1
XFILLER_0_16_421 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_7_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_7_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4748_ _2296_ VGND VGND VPWR VPWR _0269_ sky130_fd_sc_hd__clkbuf_1
X_4679_ _2262_ VGND VGND VPWR VPWR _0234_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_101_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_11_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput126 rf_rs2_i[5] VGND VGND VPWR VPWR net126 sky130_fd_sc_hd__clkbuf_1
Xinput104 rf_rs2_i[14] VGND VGND VPWR VPWR net104 sky130_fd_sc_hd__clkbuf_1
Xinput115 rf_rs2_i[24] VGND VGND VPWR VPWR net115 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_98_457 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_39_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_66_332 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_66_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_54_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_66_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_81_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_27_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_89_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3981_ net14 _1815_ _1825_ _1810_ VGND VGND VPWR VPWR _1826_ sky130_fd_sc_hd__a22o_1
XPHY_1 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_429 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2932_ i_exec_stage.data_fwd_o\[16\] _0439_ VGND VGND VPWR VPWR _0847_ sky130_fd_sc_hd__nand2_1
XFILLER_0_84_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2863_ _0384_ _0776_ _0777_ _0752_ VGND VGND VPWR VPWR _0778_ sky130_fd_sc_hd__o211a_1
X_2794_ _0448_ _0712_ VGND VGND VPWR VPWR _0713_ sky130_fd_sc_hd__or2_2
X_4602_ i_decode_stage.reg_meta_o\[72\] net87 _2207_ VGND VGND VPWR VPWR _2229_ sky130_fd_sc_hd__mux2_1
XFILLER_0_60_508 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4533_ i_decode_stage.decode_state_o\[124\] net46 _2179_ VGND VGND VPWR VPWR _2194_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_4_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4464_ net35 i_decode_stage.decode_state_o\[139\] _1967_ VGND VGND VPWR VPWR _2159_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_7_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_7_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4395_ net212 _2101_ VGND VGND VPWR VPWR _2105_ sky130_fd_sc_hd__and2_1
XFILLER_0_68_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3415_ _1156_ _1310_ _1311_ _1315_ _0448_ VGND VGND VPWR VPWR _1316_ sky130_fd_sc_hd__a32o_1
X_3346_ _1129_ _1245_ _1248_ _0868_ VGND VGND VPWR VPWR _1249_ sky130_fd_sc_hd__a22o_1
XTAP_630 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_641 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_652 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_663 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_674 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_685 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3277_ _0570_ _0472_ _0421_ VGND VGND VPWR VPWR _1182_ sky130_fd_sc_hd__mux2_1
X_5016_ clknet_leaf_39_clk_i _0196_ net282 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[120\]
+ sky130_fd_sc_hd__dfrtp_4
XFILLER_0_30_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_696 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_405 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_95_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_48_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_48_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_63_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_262 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_31_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_101_153 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_101_197 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_86_438 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_27_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_39_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_66_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4180_ _1968_ VGND VGND VPWR VPWR _0029_ sky130_fd_sc_hd__clkbuf_1
X_3200_ _0601_ i_exec_stage.alu_out\[0\] i_exec_stage.alu_out\[1\] VGND VGND VPWR
+ VPWR _1109_ sky130_fd_sc_hd__or3b_1
X_3131_ _0540_ _1042_ VGND VGND VPWR VPWR _1043_ sky130_fd_sc_hd__nor2_1
X_3062_ _0972_ _0973_ VGND VGND VPWR VPWR _0974_ sky130_fd_sc_hd__and2b_1
XFILLER_0_89_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_54_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_77_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3964_ i_exec_stage.exec_state_o\[0\] i_exec_stage.exec_state_o\[1\] i_exec_stage.exec_state_o\[7\]
+ VGND VGND VPWR VPWR _1814_ sky130_fd_sc_hd__nor3_2
XFILLER_0_9_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3895_ _1156_ _1036_ _1760_ _1771_ VGND VGND VPWR VPWR _1772_ sky130_fd_sc_hd__a31o_1
X_2915_ i_decode_stage.decode_state_o\[52\] _0339_ _0733_ VGND VGND VPWR VPWR _0830_
+ sky130_fd_sc_hd__a21oi_1
XFILLER_0_45_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2846_ _0384_ _0759_ _0760_ _0752_ VGND VGND VPWR VPWR _0761_ sky130_fd_sc_hd__o211a_1
XFILLER_0_70_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_72_176 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2777_ _0691_ _0695_ _0465_ VGND VGND VPWR VPWR _0696_ sky130_fd_sc_hd__mux2_1
XFILLER_0_13_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4516_ _2185_ VGND VGND VPWR VPWR _0148_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_13_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4447_ _2042_ _2147_ VGND VGND VPWR VPWR _2148_ sky130_fd_sc_hd__or2_1
XFILLER_0_0_181 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4378_ net206 _2085_ net207 VGND VGND VPWR VPWR _2092_ sky130_fd_sc_hd__a21oi_1
XTAP_460 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_471 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_482 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_493 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3329_ _0869_ _0884_ _1228_ _1231_ _0411_ VGND VGND VPWR VPWR _1232_ sky130_fd_sc_hd__o311a_1
XFILLER_0_48_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_48_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_91_485 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_63_187 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_86_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_86_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_94_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2700_ i_mem_slice_stage.mem_state_o\[50\] i_mem_slice_stage.mem_state_o\[11\] _0453_
+ VGND VGND VPWR VPWR _0626_ sky130_fd_sc_hd__mux2_1
X_3680_ _0344_ _0500_ _1055_ VGND VGND VPWR VPWR _1568_ sky130_fd_sc_hd__a21o_1
X_2631_ i_mem_slice_stage.mem_state_o\[65\] i_mem_slice_stage.mem_state_o\[26\] _0453_
+ VGND VGND VPWR VPWR _0564_ sky130_fd_sc_hd__mux2_1
XFILLER_0_2_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_40_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput205 net205 VGND VGND VPWR VPWR imem_addr_o[14] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_2_457 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5350_ net43 VGND VGND VPWR VPWR net235 sky130_fd_sc_hd__clkbuf_1
Xoutput216 net216 VGND VGND VPWR VPWR imem_addr_o[24] sky130_fd_sc_hd__buf_2
X_2562_ i_mem_slice_stage.mem_state_o\[89\] _0452_ _0503_ _0455_ VGND VGND VPWR VPWR
+ net251 sky130_fd_sc_hd__a22o_1
X_4301_ i_decode_stage.decode_state_o\[237\] _1840_ _2035_ VGND VGND VPWR VPWR _0083_
+ sky130_fd_sc_hd__o21a_1
Xoutput249 net249 VGND VGND VPWR VPWR rf_wr_data_o[16] sky130_fd_sc_hd__buf_2
Xoutput227 net227 VGND VGND VPWR VPWR imem_addr_o[5] sky130_fd_sc_hd__buf_2
Xoutput238 net238 VGND VGND VPWR VPWR rf_port2_reg_o[1] sky130_fd_sc_hd__clkbuf_4
X_5281_ clknet_leaf_6_clk_i _0280_ VGND VGND VPWR VPWR i_exec_stage.data_fwd_o\[15\]
+ sky130_fd_sc_hd__dfxtp_1
X_4232_ i_decode_stage.decode_state_o\[59\] i_decode_stage.fetch_state_i\[51\] _1982_
+ VGND VGND VPWR VPWR _1995_ sky130_fd_sc_hd__mux2_1
X_2493_ i_decode_stage.reg_meta_o\[10\] net268 _0441_ VGND VGND VPWR VPWR _0442_ sky130_fd_sc_hd__mux2_1
X_4163_ _1959_ VGND VGND VPWR VPWR _0021_ sky130_fd_sc_hd__clkbuf_1
X_3114_ _0746_ _1017_ _1025_ VGND VGND VPWR VPWR _1026_ sky130_fd_sc_hd__a21o_1
X_4094_ _1903_ _1908_ _1910_ VGND VGND VPWR VPWR _1912_ sky130_fd_sc_hd__and3_1
X_3045_ _0852_ _0943_ _0955_ _0956_ VGND VGND VPWR VPWR _0957_ sky130_fd_sc_hd__a211o_1
X_4996_ clknet_leaf_0_clk_i _0176_ net281 VGND VGND VPWR VPWR i_decode_stage.reg_meta_o\[57\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_92_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3947_ _0749_ VGND VGND VPWR VPWR _1802_ sky130_fd_sc_hd__inv_2
X_3878_ _1750_ _1751_ _1752_ _1755_ VGND VGND VPWR VPWR _1756_ sky130_fd_sc_hd__or4_1
X_2829_ _0556_ _0743_ VGND VGND VPWR VPWR _0744_ sky130_fd_sc_hd__and2b_1
XFILLER_0_60_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_290 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_51_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_10_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_19_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_99_393 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4850_ clknet_leaf_26_clk_i _0030_ net289 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[34\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_59_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3801_ _0590_ _1541_ _1681_ _1396_ _1682_ VGND VGND VPWR VPWR _1683_ sky130_fd_sc_hd__o221ai_2
XFILLER_0_74_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_7_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_51_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4781_ i_exec_stage.data_fwd_o\[21\] net142 _1839_ VGND VGND VPWR VPWR _2313_ sky130_fd_sc_hd__mux2_1
XFILLER_0_55_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_305 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3732_ _1600_ _1601_ _1612_ _1617_ VGND VGND VPWR VPWR net144 sky130_fd_sc_hd__a211o_4
XFILLER_0_70_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3663_ _0495_ _0507_ _0465_ VGND VGND VPWR VPWR _1552_ sky130_fd_sc_hd__mux2_1
X_2614_ i_exec_stage.data_fwd_o\[28\] _0548_ _0460_ VGND VGND VPWR VPWR _0549_ sky130_fd_sc_hd__mux2_1
XFILLER_0_70_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3594_ _1156_ _1467_ _1468_ _1486_ VGND VGND VPWR VPWR net137 sky130_fd_sc_hd__a31o_4
X_2545_ i_mem_slice_stage.mem_state_o\[90\] _0452_ _0488_ _0455_ VGND VGND VPWR VPWR
+ net252 sky130_fd_sc_hd__a22o_1
X_2476_ _0404_ _0417_ _0419_ _0420_ _0425_ VGND VGND VPWR VPWR _0426_ sky130_fd_sc_hd__o221a_1
XFILLER_0_76_41 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5264_ clknet_leaf_27_clk_i _0263_ net290 VGND VGND VPWR VPWR i_decode_stage.fetch_state_i\[62\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_76_85 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4215_ _1986_ VGND VGND VPWR VPWR _0046_ sky130_fd_sc_hd__clkbuf_1
X_5195_ clknet_leaf_22_clk_i net398 net288 VGND VGND VPWR VPWR i_mem_slice_stage.mem_state_o\[102\]
+ sky130_fd_sc_hd__dfrtp_1
X_4146_ i_decode_stage.fetch_state_i\[9\] i_decode_stage.decode_state_o\[17\] _1936_
+ VGND VGND VPWR VPWR _1951_ sky130_fd_sc_hd__mux2_1
X_4077_ _0535_ _1020_ VGND VGND VPWR VPWR _1895_ sky130_fd_sc_hd__nand2_1
XFILLER_0_92_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3028_ _0603_ _0840_ VGND VGND VPWR VPWR _0940_ sky130_fd_sc_hd__and2b_1
XFILLER_0_93_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4979_ clknet_leaf_38_clk_i _0159_ net282 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[126\]
+ sky130_fd_sc_hd__dfrtp_4
XFILLER_0_73_293 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_14_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout295 net297 VGND VGND VPWR VPWR net295 sky130_fd_sc_hd__buf_6
Xfanout284 net131 VGND VGND VPWR VPWR net284 sky130_fd_sc_hd__buf_8
XFILLER_0_56_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_71_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_71_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_21_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4000_ net7 _1807_ _1813_ _1831_ _1834_ VGND VGND VPWR VPWR i_mem_slice_stage.pre_data\[15\]
+ sky130_fd_sc_hd__a221o_1
X_4902_ clknet_leaf_18_clk_i _0082_ net297 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[236\]
+ sky130_fd_sc_hd__dfrtp_2
XFILLER_0_62_32 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_47_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4833_ clknet_leaf_42_clk_i _0013_ net280 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[17\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_7_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4764_ _2304_ VGND VGND VPWR VPWR _0277_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_28_485 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_15_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_55_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3715_ _1598_ _1599_ _1156_ VGND VGND VPWR VPWR _1601_ sky130_fd_sc_hd__o21a_1
X_4695_ net201 i_decode_stage.fetch_state_i\[42\] _1967_ VGND VGND VPWR VPWR _2270_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_101_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3646_ _0424_ _1535_ _0990_ VGND VGND VPWR VPWR _1536_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_87_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3577_ _0852_ _1469_ VGND VGND VPWR VPWR _1470_ sky130_fd_sc_hd__nand2_1
XFILLER_0_60_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_11_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2528_ i_mem_slice_stage.mem_state_o\[92\] _0452_ _0473_ _0455_ VGND VGND VPWR VPWR
+ net255 sky130_fd_sc_hd__a22o_2
X_5247_ clknet_leaf_29_clk_i _0246_ net286 VGND VGND VPWR VPWR i_decode_stage.fetch_state_i\[45\]
+ sky130_fd_sc_hd__dfrtp_1
Xhold26 i_exec_stage.exec_state_o\[35\] VGND VGND VPWR VPWR net363 sky130_fd_sc_hd__clkdlybuf4s25_1
X_2459_ i_decode_stage.decode_state_o\[238\] i_decode_stage.decode_state_o\[239\]
+ VGND VGND VPWR VPWR _0409_ sky130_fd_sc_hd__nor2_2
Xhold15 i_exec_stage.exec_state_o\[22\] VGND VGND VPWR VPWR net352 sky130_fd_sc_hd__clkdlybuf4s25_1
Xhold37 i_exec_stage.exec_state_o\[24\] VGND VGND VPWR VPWR net374 sky130_fd_sc_hd__clkdlybuf4s25_1
X_5178_ clknet_leaf_43_clk_i net382 net280 VGND VGND VPWR VPWR i_mem_slice_stage.mem_state_o\[85\]
+ sky130_fd_sc_hd__dfrtp_1
Xhold59 i_exec_stage.exec_state_o\[44\] VGND VGND VPWR VPWR net396 sky130_fd_sc_hd__clkdlybuf4s25_1
Xhold48 i_exec_stage.exec_state_o\[54\] VGND VGND VPWR VPWR net385 sky130_fd_sc_hd__clkdlybuf4s25_1
X_4129_ net63 net35 net65 net36 VGND VGND VPWR VPWR _1942_ sky130_fd_sc_hd__or4_1
Xcore_306 VGND VGND VPWR VPWR core_306/HI imem_wdata_o[2] sky130_fd_sc_hd__conb_1
Xcore_317 VGND VGND VPWR VPWR core_317/HI imem_wdata_o[13] sky130_fd_sc_hd__conb_1
XFILLER_0_78_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xcore_328 VGND VGND VPWR VPWR core_328/HI imem_wdata_o[24] sky130_fd_sc_hd__conb_1
XFILLER_0_38_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_485 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_46_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_34_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_61_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_14_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_1083 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1072 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1061 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1050 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1094 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3500_ _0589_ _1216_ _1179_ _1313_ _1396_ VGND VGND VPWR VPWR _1397_ sky130_fd_sc_hd__a32o_1
XFILLER_0_4_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4480_ i_decode_stage.reg_meta_o\[12\] net127 _2012_ VGND VGND VPWR VPWR _2167_ sky130_fd_sc_hd__mux2_1
X_3431_ _1044_ _1326_ _1330_ _1041_ VGND VGND VPWR VPWR _1331_ sky130_fd_sc_hd__o22a_1
XTAP_801 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3362_ _0867_ _0884_ _1228_ _0868_ VGND VGND VPWR VPWR _1264_ sky130_fd_sc_hd__o31a_1
X_5101_ clknet_leaf_12_clk_i i_mem_slice_stage.pre_data\[4\] net293 VGND VGND VPWR
+ VPWR i_mem_slice_stage.mem_state_o\[4\] sky130_fd_sc_hd__dfrtp_1
XTAP_812 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_823 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_834 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3293_ _1197_ VGND VGND VPWR VPWR _1198_ sky130_fd_sc_hd__buf_8
XTAP_845 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_856 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_867 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5032_ clknet_leaf_13_clk_i i_exec_stage.alu_out\[0\] net293 VGND VGND VPWR VPWR
+ i_exec_stage.exec_state_o\[7\] sky130_fd_sc_hd__dfrtp_1
XTAP_889 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_878 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_87_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_7_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4816_ _1839_ i_decode_stage.decode_state_o\[4\] i_exec_stage.valid _2330_ VGND VGND
+ VPWR VPWR _0303_ sky130_fd_sc_hd__a31o_1
XFILLER_0_16_433 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_16_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4747_ i_exec_stage.data_fwd_o\[4\] net155 _1839_ VGND VGND VPWR VPWR _2296_ sky130_fd_sc_hd__mux2_1
X_4678_ i_decode_stage.fetch_state_i\[1\] net211 _2234_ VGND VGND VPWR VPWR _2262_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_31_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3629_ _0590_ _1358_ VGND VGND VPWR VPWR _1520_ sky130_fd_sc_hd__or2_1
XFILLER_0_31_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_3_393 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xinput127 rf_rs2_i[6] VGND VGND VPWR VPWR net127 sky130_fd_sc_hd__clkbuf_1
Xinput105 rf_rs2_i[15] VGND VGND VPWR VPWR net105 sky130_fd_sc_hd__clkbuf_1
Xinput116 rf_rs2_i[25] VGND VGND VPWR VPWR net116 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_98_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_66_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_81_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_369 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_22_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_57 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3980_ net5 net22 i_exec_stage.exec_state_o\[8\] VGND VGND VPWR VPWR _1825_ sky130_fd_sc_hd__mux2_1
XPHY_2 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2931_ _0844_ _0845_ _0439_ VGND VGND VPWR VPWR _0846_ sky130_fd_sc_hd__o21bai_2
XFILLER_0_43_89 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_69_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_69_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4601_ _2228_ VGND VGND VPWR VPWR _0190_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_57_399 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2862_ i_decode_stage.decode_state_o\[64\] _0731_ VGND VGND VPWR VPWR _0777_ sky130_fd_sc_hd__nand2_1
X_2793_ _0409_ _0592_ VGND VGND VPWR VPWR _0712_ sky130_fd_sc_hd__nand2_4
X_4532_ _2193_ VGND VGND VPWR VPWR _0156_ sky130_fd_sc_hd__clkbuf_1
X_4463_ _2158_ VGND VGND VPWR VPWR _0122_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_13_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3414_ _1088_ _1312_ _1314_ _0707_ VGND VGND VPWR VPWR _1315_ sky130_fd_sc_hd__a2bb2o_1
X_4394_ net141 _2042_ _2045_ _2103_ _2104_ VGND VGND VPWR VPWR _0107_ sky130_fd_sc_hd__a221o_1
X_3345_ _1199_ _1246_ _1247_ VGND VGND VPWR VPWR _1248_ sky130_fd_sc_hd__or3_1
XTAP_620 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_631 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_642 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3276_ _0486_ _0502_ _0421_ VGND VGND VPWR VPWR _1181_ sky130_fd_sc_hd__mux2_1
XTAP_653 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_664 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_675 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_686 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5015_ clknet_leaf_40_clk_i _0195_ net282 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[119\]
+ sky130_fd_sc_hd__dfrtp_2
XTAP_697 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_85 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_95_417 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_63_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_101_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_101_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_86_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_98_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_13_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_66_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3130_ _0344_ _0427_ VGND VGND VPWR VPWR _1042_ sky130_fd_sc_hd__nand2_1
XFILLER_0_38_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3061_ _0622_ _0971_ VGND VGND VPWR VPWR _0973_ sky130_fd_sc_hd__nand2_1
XFILLER_0_89_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3963_ _1812_ VGND VGND VPWR VPWR _1813_ sky130_fd_sc_hd__buf_2
XFILLER_0_85_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3894_ _0712_ _1766_ _1770_ VGND VGND VPWR VPWR _1771_ sky130_fd_sc_hd__o21ai_1
X_2914_ _0386_ _0826_ _0827_ _0828_ VGND VGND VPWR VPWR _0829_ sky130_fd_sc_hd__o31ai_4
XFILLER_0_92_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_45_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2845_ i_decode_stage.decode_state_o\[66\] _0731_ VGND VGND VPWR VPWR _0760_ sky130_fd_sc_hd__nand2_1
XFILLER_0_72_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4515_ i_decode_stage.reg_meta_o\[29\] net114 _2179_ VGND VGND VPWR VPWR _2185_ sky130_fd_sc_hd__mux2_1
X_2776_ _0451_ _0693_ _0694_ VGND VGND VPWR VPWR _0695_ sky130_fd_sc_hd__o21a_1
XFILLER_0_79_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4446_ net221 _2140_ _2146_ VGND VGND VPWR VPWR _2147_ sky130_fd_sc_hd__o21a_1
X_4377_ net206 net207 _2085_ VGND VGND VPWR VPWR _2091_ sky130_fd_sc_hd__and3_1
XFILLER_0_0_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_450 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3328_ _0884_ _1228_ _0869_ VGND VGND VPWR VPWR _1231_ sky130_fd_sc_hd__o21ai_1
XTAP_461 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_472 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_483 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_494 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3259_ _1162_ _1163_ VGND VGND VPWR VPWR _1164_ sky130_fd_sc_hd__or2_1
XFILLER_0_95_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_76_450 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_48_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_420 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_76_483 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_24_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_8_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_63_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_74_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_82_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2630_ _0451_ _0561_ _0462_ _0562_ VGND VGND VPWR VPWR _0563_ sky130_fd_sc_hd__a2bb2o_4
Xoutput206 net206 VGND VGND VPWR VPWR imem_addr_o[15] sky130_fd_sc_hd__buf_2
Xoutput217 net217 VGND VGND VPWR VPWR imem_addr_o[25] sky130_fd_sc_hd__buf_2
X_2561_ i_mem_slice_stage.mem_state_o\[57\] i_mem_slice_stage.mem_state_o\[18\] _0453_
+ VGND VGND VPWR VPWR _0503_ sky130_fd_sc_hd__mux2_1
X_4300_ net38 _2031_ _2033_ _1928_ VGND VGND VPWR VPWR _2035_ sky130_fd_sc_hd__a211o_1
X_5280_ clknet_leaf_41_clk_i _0279_ VGND VGND VPWR VPWR i_exec_stage.data_fwd_o\[14\]
+ sky130_fd_sc_hd__dfxtp_1
Xoutput228 net228 VGND VGND VPWR VPWR imem_addr_o[6] sky130_fd_sc_hd__buf_2
Xoutput239 net239 VGND VGND VPWR VPWR rf_port2_reg_o[2] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_2_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2492_ _0324_ _0326_ VGND VGND VPWR VPWR _0441_ sky130_fd_sc_hd__nor2_1
XFILLER_0_49_22 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4231_ _1994_ VGND VGND VPWR VPWR _0054_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_4_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4162_ i_decode_stage.fetch_state_i\[17\] i_decode_stage.decode_state_o\[25\] _1936_
+ VGND VGND VPWR VPWR _1959_ sky130_fd_sc_hd__mux2_1
X_3113_ _1023_ _1024_ VGND VGND VPWR VPWR _1025_ sky130_fd_sc_hd__nor2_2
X_4093_ _1903_ _1908_ _1910_ VGND VGND VPWR VPWR _1911_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_65_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3044_ _0617_ _0849_ VGND VGND VPWR VPWR _0956_ sky130_fd_sc_hd__and2b_1
XFILLER_0_77_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4995_ clknet_leaf_0_clk_i _0175_ net281 VGND VGND VPWR VPWR i_decode_stage.reg_meta_o\[56\]
+ sky130_fd_sc_hd__dfrtp_1
X_3946_ _0601_ _1801_ _1800_ _0932_ _1777_ VGND VGND VPWR VPWR net185 sky130_fd_sc_hd__a221o_1
XFILLER_0_45_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_58_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_347 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_73_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_90_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3877_ _1753_ _1754_ _1024_ VGND VGND VPWR VPWR _1755_ sky130_fd_sc_hd__a21oi_1
X_2828_ _2333_ _0741_ _0742_ VGND VGND VPWR VPWR _0743_ sky130_fd_sc_hd__a21o_1
X_2759_ i_mem_slice_stage.mem_state_o\[44\] i_mem_slice_stage.mem_state_o\[5\] _0453_
+ VGND VGND VPWR VPWR _0679_ sky130_fd_sc_hd__mux2_1
X_4429_ net218 _2125_ _2132_ VGND VGND VPWR VPWR _2133_ sky130_fd_sc_hd__o21a_1
XTAP_291 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_280 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_431 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_91_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_99_372 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_99_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_59_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3800_ _0707_ _0660_ _1603_ VGND VGND VPWR VPWR _1682_ sky130_fd_sc_hd__or3_1
XFILLER_0_74_217 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4780_ _2312_ VGND VGND VPWR VPWR _0285_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_27_133 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3731_ _0799_ _1615_ _1616_ VGND VGND VPWR VPWR _1617_ sky130_fd_sc_hd__o21a_1
XFILLER_0_82_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_15_317 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_27_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_51_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3662_ _1129_ _1188_ _1479_ VGND VGND VPWR VPWR _1551_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_30_309 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2613_ net261 i_decode_stage.reg_meta_o\[71\] _0457_ VGND VGND VPWR VPWR _0548_ sky130_fd_sc_hd__mux2_1
X_3593_ _0411_ _1470_ _1471_ _1485_ VGND VGND VPWR VPWR _1486_ sky130_fd_sc_hd__a31o_1
XFILLER_0_2_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2544_ i_mem_slice_stage.mem_state_o\[58\] i_mem_slice_stage.mem_state_o\[19\] _0453_
+ VGND VGND VPWR VPWR _0488_ sky130_fd_sc_hd__mux2_1
X_2475_ _0422_ _0404_ _0424_ VGND VGND VPWR VPWR _0425_ sky130_fd_sc_hd__a21o_1
X_5263_ clknet_leaf_19_clk_i _0262_ net296 VGND VGND VPWR VPWR i_decode_stage.fetch_state_i\[61\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_76_53 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4214_ i_decode_stage.decode_state_o\[50\] i_decode_stage.fetch_state_i\[42\] _1982_
+ VGND VGND VPWR VPWR _1986_ sky130_fd_sc_hd__mux2_1
X_5194_ clknet_leaf_25_clk_i net343 net289 VGND VGND VPWR VPWR i_mem_slice_stage.mem_state_o\[101\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_76_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4145_ _1950_ VGND VGND VPWR VPWR _0012_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_78_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4076_ _0566_ _0759_ _0768_ _0561_ _1893_ VGND VGND VPWR VPWR _1894_ sky130_fd_sc_hd__o221ai_4
X_3027_ _0640_ _0831_ VGND VGND VPWR VPWR _0939_ sky130_fd_sc_hd__and2b_1
X_4978_ clknet_leaf_34_clk_i _0158_ net284 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[125\]
+ sky130_fd_sc_hd__dfrtp_4
X_3929_ _1791_ VGND VGND VPWR VPWR net177 sky130_fd_sc_hd__inv_2
XFILLER_0_46_464 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_73_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_61_423 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_33_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xfanout285 net291 VGND VGND VPWR VPWR net285 sky130_fd_sc_hd__buf_12
Xfanout296 net297 VGND VGND VPWR VPWR net296 sky130_fd_sc_hd__buf_12
XFILLER_0_24_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_12_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_52_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_87_364 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_1_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4901_ clknet_leaf_20_clk_i _0081_ net296 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[235\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_62_44 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4832_ clknet_leaf_43_clk_i _0012_ net280 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[16\]
+ sky130_fd_sc_hd__dfrtp_1
X_4763_ i_exec_stage.data_fwd_o\[12\] net133 _1839_ VGND VGND VPWR VPWR _2304_ sky130_fd_sc_hd__mux2_1
XFILLER_0_15_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4694_ _2269_ VGND VGND VPWR VPWR _0242_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_28_497 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_43_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3714_ _1598_ _1599_ VGND VGND VPWR VPWR _1600_ sky130_fd_sc_hd__nand2_1
XFILLER_0_70_253 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3645_ _0417_ _0507_ _0989_ _0413_ _1534_ VGND VGND VPWR VPWR _1535_ sky130_fd_sc_hd__o221a_1
X_3576_ _1460_ _1446_ _1448_ VGND VGND VPWR VPWR _1469_ sky130_fd_sc_hd__a21oi_1
X_2527_ i_mem_slice_stage.mem_state_o\[60\] i_mem_slice_stage.mem_state_o\[21\] _0453_
+ VGND VGND VPWR VPWR _0473_ sky130_fd_sc_hd__mux2_1
X_2458_ i_decode_stage.decode_state_o\[236\] i_decode_stage.decode_state_o\[237\]
+ VGND VGND VPWR VPWR _0408_ sky130_fd_sc_hd__or2_1
X_5246_ clknet_leaf_29_clk_i _0245_ net285 VGND VGND VPWR VPWR i_decode_stage.fetch_state_i\[44\]
+ sky130_fd_sc_hd__dfrtp_1
Xhold27 i_exec_stage.exec_state_o\[28\] VGND VGND VPWR VPWR net364 sky130_fd_sc_hd__clkdlybuf4s25_1
Xhold16 i_decode_stage.decode_state_o\[39\] VGND VGND VPWR VPWR net353 sky130_fd_sc_hd__clkdlybuf4s25_1
Xhold38 i_exec_stage.exec_state_o\[20\] VGND VGND VPWR VPWR net375 sky130_fd_sc_hd__clkdlybuf4s25_1
Xhold49 i_exec_stage.exec_state_o\[16\] VGND VGND VPWR VPWR net386 sky130_fd_sc_hd__clkdlybuf4s25_1
X_5177_ clknet_leaf_41_clk_i net377 net281 VGND VGND VPWR VPWR i_mem_slice_stage.mem_state_o\[84\]
+ sky130_fd_sc_hd__dfrtp_1
X_2389_ _2333_ _0336_ _0341_ VGND VGND VPWR VPWR _0342_ sky130_fd_sc_hd__a21bo_1
X_4128_ i_decode_stage.decode_state_o\[6\] _1928_ _1932_ _1941_ _1940_ VGND VGND VPWR
+ VPWR _0004_ sky130_fd_sc_hd__a221o_1
Xcore_307 VGND VGND VPWR VPWR core_307/HI imem_wdata_o[3] sky130_fd_sc_hd__conb_1
X_4059_ _0600_ _0838_ _0855_ _0606_ VGND VGND VPWR VPWR _1877_ sky130_fd_sc_hd__o22a_1
Xcore_318 VGND VGND VPWR VPWR core_318/HI imem_wdata_o[14] sky130_fd_sc_hd__conb_1
Xcore_329 VGND VGND VPWR VPWR core_329/HI imem_wdata_o[25] sky130_fd_sc_hd__conb_1
XFILLER_0_38_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_46_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_53_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_19_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_88_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_88_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_88_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_69_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1040 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1073 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1062 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1051 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_1095 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1084 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_44_209 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_52_253 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3430_ _0660_ _1207_ _1329_ VGND VGND VPWR VPWR _1330_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_0_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3361_ _0881_ _0899_ _1234_ _1262_ VGND VGND VPWR VPWR _1263_ sky130_fd_sc_hd__o31a_1
X_5100_ clknet_leaf_13_clk_i i_mem_slice_stage.pre_data\[3\] net293 VGND VGND VPWR
+ VPWR i_mem_slice_stage.mem_state_o\[3\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_57_44 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_802 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_813 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_824 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_835 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3292_ i_decode_stage.decode_state_o\[239\] i_decode_stage.decode_state_o\[238\]
+ i_decode_stage.decode_state_o\[237\] i_decode_stage.decode_state_o\[236\] VGND VGND
+ VPWR VPWR _1197_ sky130_fd_sc_hd__and4b_1
X_5031_ clknet_leaf_33_clk_i i_decode_stage.decode_state_o\[7\] net284 VGND VGND VPWR
+ VPWR i_exec_stage.exec_state_o\[6\] sky130_fd_sc_hd__dfrtp_1
XTAP_846 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_857 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_868 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_879 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4815_ _1839_ i_exec_stage.data_fwd_o\[38\] VGND VGND VPWR VPWR _2330_ sky130_fd_sc_hd__and2b_1
XFILLER_0_16_445 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4746_ _2295_ VGND VGND VPWR VPWR _0268_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_16_489 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4677_ _2261_ VGND VGND VPWR VPWR _0233_ sky130_fd_sc_hd__clkbuf_1
X_3628_ _1433_ _1518_ _0523_ VGND VGND VPWR VPWR _1519_ sky130_fd_sc_hd__mux2_1
XFILLER_0_3_361 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3559_ _0593_ _0448_ _0584_ _1451_ _1452_ VGND VGND VPWR VPWR _1453_ sky130_fd_sc_hd__o221a_1
Xinput106 rf_rs2_i[16] VGND VGND VPWR VPWR net106 sky130_fd_sc_hd__clkbuf_1
Xinput117 rf_rs2_i[26] VGND VGND VPWR VPWR net117 sky130_fd_sc_hd__clkbuf_1
X_5229_ clknet_leaf_27_clk_i _0228_ net290 VGND VGND VPWR VPWR i_decode_stage.fetch_state_i\[27\]
+ sky130_fd_sc_hd__dfrtp_1
Xinput128 rf_rs2_i[7] VGND VGND VPWR VPWR net128 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_78_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_81_337 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_19_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_90 _0346_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_309 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_27_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_89_426 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2930_ _0324_ _0326_ i_decode_stage.reg_meta_o\[21\] VGND VGND VPWR VPWR _0845_ sky130_fd_sc_hd__o21a_1
XFILLER_0_43_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_153 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_84_197 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4600_ i_decode_stage.reg_meta_o\[71\] net86 _2207_ VGND VGND VPWR VPWR _2228_ sky130_fd_sc_hd__mux2_1
X_2861_ i_exec_stage.data_fwd_o\[25\] _0726_ _0775_ VGND VGND VPWR VPWR _0776_ sky130_fd_sc_hd__o21ai_4
Xclkbuf_leaf_19_clk_i clknet_2_3__leaf_clk_i VGND VGND VPWR VPWR clknet_leaf_19_clk_i
+ sky130_fd_sc_hd__clkbuf_16
X_2792_ _0585_ _0595_ _0710_ VGND VGND VPWR VPWR _0711_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_40_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4531_ i_decode_stage.reg_meta_o\[37\] net123 _2179_ VGND VGND VPWR VPWR _2193_ sky130_fd_sc_hd__mux2_1
X_4462_ net65 i_decode_stage.decode_state_o\[138\] _1967_ VGND VGND VPWR VPWR _2158_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_40_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3413_ _0523_ _0594_ _1177_ _1313_ VGND VGND VPWR VPWR _1314_ sky130_fd_sc_hd__a31o_1
X_4393_ net210 _1927_ VGND VGND VPWR VPWR _2104_ sky130_fd_sc_hd__and2_1
X_3344_ _1149_ _1092_ _0867_ _1198_ VGND VGND VPWR VPWR _1247_ sky130_fd_sc_hd__a22o_1
XTAP_610 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_621 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_632 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_643 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3275_ _0525_ _1177_ _1179_ VGND VGND VPWR VPWR _1180_ sky130_fd_sc_hd__a21o_1
XTAP_654 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_665 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_676 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5014_ clknet_leaf_2_clk_i _0194_ net283 VGND VGND VPWR VPWR i_decode_stage.reg_meta_o\[75\]
+ sky130_fd_sc_hd__dfrtp_1
XTAP_687 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_698 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_95_429 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_63_337 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_8_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4729_ net219 i_decode_stage.fetch_state_i\[59\] _1927_ VGND VGND VPWR VPWR _2287_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_13_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_54_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_81_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_10_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_1_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3060_ _0622_ _0971_ VGND VGND VPWR VPWR _0972_ sky130_fd_sc_hd__nor2_2
XFILLER_0_89_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3962_ i_exec_stage.exec_state_o\[1\] i_exec_stage.exec_state_o\[0\] VGND VGND VPWR
+ VPWR _1812_ sky130_fd_sc_hd__and2b_1
XFILLER_0_70_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_70_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_70_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_85_473 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3893_ _0448_ _1478_ _1769_ VGND VGND VPWR VPWR _1770_ sky130_fd_sc_hd__o21ba_1
X_2913_ i_exec_stage.data_fwd_o\[13\] _0311_ _0316_ _0320_ VGND VGND VPWR VPWR _0828_
+ sky130_fd_sc_hd__or4_2
XFILLER_0_45_337 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2844_ i_exec_stage.data_fwd_o\[27\] _0726_ _0758_ VGND VGND VPWR VPWR _0759_ sky130_fd_sc_hd__o21ai_4
XFILLER_0_72_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_60_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_79_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_13_234 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4514_ _2184_ VGND VGND VPWR VPWR _0147_ sky130_fd_sc_hd__clkbuf_1
X_2775_ i_decode_stage.decode_state_o\[128\] _0631_ i_decode_stage.decode_state_o\[140\]
+ _0491_ _0347_ VGND VGND VPWR VPWR _0694_ sky130_fd_sc_hd__a221o_1
XFILLER_0_53_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4445_ _1926_ _2145_ VGND VGND VPWR VPWR _2146_ sky130_fd_sc_hd__nor2_1
X_4376_ net137 _2042_ _2090_ VGND VGND VPWR VPWR _0103_ sky130_fd_sc_hd__a21o_1
X_3327_ _1230_ VGND VGND VPWR VPWR net156 sky130_fd_sc_hd__buf_4
XTAP_440 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_451 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_462 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_473 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_484 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3258_ _0582_ _0691_ VGND VGND VPWR VPWR _1163_ sky130_fd_sc_hd__nor2_1
XTAP_495 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3189_ _1074_ _0447_ _1086_ _1087_ _1100_ VGND VGND VPWR VPWR _1101_ sky130_fd_sc_hd__a221o_1
XFILLER_0_76_495 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_91_432 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_5_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_24_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_82_421 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_42_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2560_ _0344_ _0495_ _0501_ VGND VGND VPWR VPWR _0502_ sky130_fd_sc_hd__a21o_1
Xoutput207 net207 VGND VGND VPWR VPWR imem_addr_o[16] sky130_fd_sc_hd__buf_2
XFILLER_0_50_351 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2491_ i_mem_slice_stage.mem_state_o\[75\] _0328_ _0440_ _0330_ VGND VGND VPWR VPWR
+ net268 sky130_fd_sc_hd__a22o_1
Xoutput229 net229 VGND VGND VPWR VPWR imem_addr_o[7] sky130_fd_sc_hd__clkbuf_4
Xoutput218 net218 VGND VGND VPWR VPWR imem_addr_o[26] sky130_fd_sc_hd__buf_2
XFILLER_0_49_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4230_ i_decode_stage.decode_state_o\[58\] i_decode_stage.fetch_state_i\[50\] _1982_
+ VGND VGND VPWR VPWR _1994_ sky130_fd_sc_hd__mux2_1
X_4161_ _1958_ VGND VGND VPWR VPWR _0020_ sky130_fd_sc_hd__clkbuf_1
X_3112_ _0537_ _1022_ VGND VGND VPWR VPWR _1024_ sky130_fd_sc_hd__and2_1
X_4092_ i_decode_stage.decode_state_o\[240\] _1909_ VGND VGND VPWR VPWR _1910_ sky130_fd_sc_hd__xor2_1
X_3043_ _0859_ _0954_ VGND VGND VPWR VPWR _0955_ sky130_fd_sc_hd__nor2_1
XFILLER_0_77_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4994_ clknet_leaf_44_clk_i _0174_ net281 VGND VGND VPWR VPWR i_decode_stage.reg_meta_o\[55\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_58_462 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3945_ _0759_ VGND VGND VPWR VPWR _1801_ sky130_fd_sc_hd__inv_2
XFILLER_0_18_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3876_ _0417_ _0537_ _1023_ _0413_ _0424_ VGND VGND VPWR VPWR _1754_ sky130_fd_sc_hd__o221a_1
XFILLER_0_33_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2827_ i_decode_stage.decode_state_o\[68\] _0731_ _0733_ VGND VGND VPWR VPWR _0742_
+ sky130_fd_sc_hd__a21oi_1
X_2758_ i_exec_stage.data_fwd_o\[6\] _0460_ VGND VGND VPWR VPWR _0678_ sky130_fd_sc_hd__or2_1
X_4428_ _1926_ _2131_ VGND VGND VPWR VPWR _2132_ sky130_fd_sc_hd__nor2_1
X_2689_ i_decode_stage.decode_state_o\[119\] _0493_ VGND VGND VPWR VPWR _0616_ sky130_fd_sc_hd__nand2_1
X_4359_ net202 _1927_ VGND VGND VPWR VPWR _2078_ sky130_fd_sc_hd__and2_1
XTAP_292 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_281 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_270 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_76_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_36_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_24_329 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_99_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_74_229 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_27_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_57 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3730_ _0799_ _1615_ _1158_ VGND VGND VPWR VPWR _1616_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_82_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_82_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_15_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_42_126 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3661_ _0983_ _1549_ VGND VGND VPWR VPWR _1550_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_70_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2612_ i_mem_slice_stage.mem_state_o\[98\] _0452_ _0547_ _0455_ VGND VGND VPWR VPWR
+ net261 sky130_fd_sc_hd__a22o_1
XFILLER_0_42_148 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3592_ _1204_ _1476_ _1484_ VGND VGND VPWR VPWR _1485_ sky130_fd_sc_hd__a21bo_1
X_2543_ _0472_ _0486_ _0421_ VGND VGND VPWR VPWR _0487_ sky130_fd_sc_hd__mux2_1
XFILLER_0_11_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_2_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_23_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_50_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2474_ _0423_ VGND VGND VPWR VPWR _0424_ sky130_fd_sc_hd__buf_6
X_5262_ clknet_leaf_19_clk_i _0261_ net296 VGND VGND VPWR VPWR i_decode_stage.fetch_state_i\[60\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_55_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_76_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4213_ _1985_ VGND VGND VPWR VPWR _0045_ sky130_fd_sc_hd__clkbuf_1
X_5193_ clknet_leaf_27_clk_i net410 net289 VGND VGND VPWR VPWR i_mem_slice_stage.mem_state_o\[100\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_48_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4144_ i_decode_stage.fetch_state_i\[8\] i_decode_stage.decode_state_o\[16\] _1936_
+ VGND VGND VPWR VPWR _1950_ sky130_fd_sc_hd__mux2_1
X_4075_ _0554_ _0741_ _0749_ _0549_ VGND VGND VPWR VPWR _1893_ sky130_fd_sc_hd__o22a_1
X_3026_ _0897_ _0904_ _0937_ VGND VGND VPWR VPWR _0938_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_93_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_18_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_58_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4977_ clknet_leaf_38_clk_i _0157_ net282 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[124\]
+ sky130_fd_sc_hd__dfrtp_4
XFILLER_0_46_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3928_ _0578_ _0978_ _0601_ VGND VGND VPWR VPWR _1791_ sky130_fd_sc_hd__mux2_1
XFILLER_0_73_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3859_ _0415_ _0738_ _1736_ _0709_ _1737_ VGND VGND VPWR VPWR _1738_ sky130_fd_sc_hd__o221a_1
XFILLER_0_61_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout297 net131 VGND VGND VPWR VPWR net297 sky130_fd_sc_hd__clkbuf_16
Xfanout286 net291 VGND VGND VPWR VPWR net286 sky130_fd_sc_hd__buf_6
XFILLER_0_69_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_96_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_49_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_64_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_75_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4900_ clknet_leaf_34_clk_i _0080_ net288 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[234\]
+ sky130_fd_sc_hd__dfrtp_4
XFILLER_0_87_376 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4831_ clknet_leaf_42_clk_i _0011_ net280 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[15\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_62_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_28_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4762_ _2303_ VGND VGND VPWR VPWR _0276_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_7_337 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4693_ net231 i_decode_stage.fetch_state_i\[41\] _1967_ VGND VGND VPWR VPWR _2269_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_15_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3713_ _0809_ _1595_ _0821_ VGND VGND VPWR VPWR _1599_ sky130_fd_sc_hd__a21o_1
XFILLER_0_3_510 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3644_ _1198_ _0989_ VGND VGND VPWR VPWR _1534_ sky130_fd_sc_hd__nand2_1
XFILLER_0_70_265 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3575_ _0942_ _1464_ _0852_ VGND VGND VPWR VPWR _1468_ sky130_fd_sc_hd__o21ai_1
X_2526_ _0344_ _0464_ _0471_ VGND VGND VPWR VPWR _0472_ sky130_fd_sc_hd__a21o_1
X_2457_ _0345_ _0382_ _0405_ VGND VGND VPWR VPWR _0407_ sky130_fd_sc_hd__o21ai_1
X_5245_ clknet_leaf_29_clk_i _0244_ net285 VGND VGND VPWR VPWR i_decode_stage.fetch_state_i\[43\]
+ sky130_fd_sc_hd__dfrtp_1
Xhold17 i_exec_stage.exec_state_o\[6\] VGND VGND VPWR VPWR net354 sky130_fd_sc_hd__clkdlybuf4s25_1
Xhold28 i_exec_stage.exec_state_o\[12\] VGND VGND VPWR VPWR net365 sky130_fd_sc_hd__clkdlybuf4s25_1
Xhold39 i_exec_stage.exec_state_o\[10\] VGND VGND VPWR VPWR net376 sky130_fd_sc_hd__clkdlybuf4s25_1
X_5176_ clknet_leaf_42_clk_i net399 net281 VGND VGND VPWR VPWR i_mem_slice_stage.mem_state_o\[83\]
+ sky130_fd_sc_hd__dfrtp_1
X_2388_ i_decode_stage.decode_state_o\[124\] _0337_ i_decode_stage.decode_state_o\[232\]
+ _0340_ VGND VGND VPWR VPWR _0341_ sky130_fd_sc_hd__a31o_1
X_4127_ net62 net60 _0722_ VGND VGND VPWR VPWR _1941_ sky130_fd_sc_hd__and3_1
XFILLER_0_78_321 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xcore_308 VGND VGND VPWR VPWR core_308/HI imem_wdata_o[4] sky130_fd_sc_hd__conb_1
X_4058_ _1872_ _1873_ _1874_ _1875_ VGND VGND VPWR VPWR _1876_ sky130_fd_sc_hd__or4_1
Xcore_319 VGND VGND VPWR VPWR core_319/HI imem_wdata_o[15] sky130_fd_sc_hd__conb_1
X_3009_ _0920_ VGND VGND VPWR VPWR _0921_ sky130_fd_sc_hd__inv_2
XFILLER_0_78_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_16_49 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_16_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1030 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_376 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1074 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1063 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1052 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1041 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1096 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1085 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_52_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_52_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_40_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_52_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3360_ _0430_ _1261_ VGND VGND VPWR VPWR _1262_ sky130_fd_sc_hd__nor2_1
XTAP_803 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_814 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_825 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3291_ _0582_ _0691_ VGND VGND VPWR VPWR _1196_ sky130_fd_sc_hd__nand2_1
X_5030_ clknet_leaf_26_clk_i i_decode_stage.decode_state_o\[6\] net289 VGND VGND VPWR
+ VPWR i_exec_stage.exec_state_o\[5\] sky130_fd_sc_hd__dfrtp_1
XTAP_836 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_847 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_858 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_869 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_18_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_48_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4814_ _2329_ VGND VGND VPWR VPWR _0302_ sky130_fd_sc_hd__clkbuf_1
X_4745_ i_exec_stage.data_fwd_o\[3\] net152 _1839_ VGND VGND VPWR VPWR _2295_ sky130_fd_sc_hd__mux2_1
XFILLER_0_83_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_16_457 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_31_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4676_ i_decode_stage.fetch_state_i\[0\] net200 _2234_ VGND VGND VPWR VPWR _2261_
+ sky130_fd_sc_hd__mux2_1
X_3627_ _1472_ _1517_ _0422_ VGND VGND VPWR VPWR _1518_ sky130_fd_sc_hd__mux2_1
XFILLER_0_98_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_31_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_101_337 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3558_ _0662_ _1115_ _1348_ VGND VGND VPWR VPWR _1452_ sky130_fd_sc_hd__or3_1
XFILLER_0_3_373 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2509_ _0376_ _0377_ _0378_ VGND VGND VPWR VPWR _0456_ sky130_fd_sc_hd__or3_1
Xinput107 rf_rs2_i[17] VGND VGND VPWR VPWR net107 sky130_fd_sc_hd__clkbuf_1
Xinput118 rf_rs2_i[27] VGND VGND VPWR VPWR net118 sky130_fd_sc_hd__clkbuf_1
X_3489_ _0935_ _1366_ _1379_ VGND VGND VPWR VPWR _1386_ sky130_fd_sc_hd__a21oi_1
Xinput129 rf_rs2_i[8] VGND VGND VPWR VPWR net129 sky130_fd_sc_hd__clkbuf_1
X_5228_ clknet_leaf_26_clk_i _0227_ net289 VGND VGND VPWR VPWR i_decode_stage.fetch_state_i\[26\]
+ sky130_fd_sc_hd__dfrtp_1
X_5159_ clknet_leaf_12_clk_i net389 net294 VGND VGND VPWR VPWR i_mem_slice_stage.mem_state_o\[66\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_39_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_81_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_91 net153 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_80 net150 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_30_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_89_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_89_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_4 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2860_ i_decode_stage.reg_meta_o\[30\] _0727_ _0386_ _0774_ VGND VGND VPWR VPWR _0775_
+ sky130_fd_sc_hd__a211o_1
XFILLER_0_57_379 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_84_165 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2791_ _0590_ _0661_ _0708_ _0709_ VGND VGND VPWR VPWR _0710_ sky130_fd_sc_hd__o211a_1
XFILLER_0_13_405 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4530_ _2192_ VGND VGND VPWR VPWR _0155_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_13_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4461_ _2157_ VGND VGND VPWR VPWR _0121_ sky130_fd_sc_hd__clkbuf_1
X_3412_ _0545_ _1216_ VGND VGND VPWR VPWR _1313_ sky130_fd_sc_hd__and2_1
XFILLER_0_0_321 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_68_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4392_ _2101_ _2102_ VGND VGND VPWR VPWR _2103_ sky130_fd_sc_hd__nor2_1
XTAP_600 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_365 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_611 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_622 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_633 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3343_ _0413_ _0867_ VGND VGND VPWR VPWR _1246_ sky130_fd_sc_hd__nor2_1
X_3274_ _0525_ _1178_ VGND VGND VPWR VPWR _1179_ sky130_fd_sc_hd__nor2_1
XTAP_644 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_655 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_666 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_677 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5013_ clknet_leaf_2_clk_i _0193_ net283 VGND VGND VPWR VPWR i_decode_stage.reg_meta_o\[74\]
+ sky130_fd_sc_hd__dfrtp_1
XTAP_688 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_699 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_8_421 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_63_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2989_ _0677_ _0880_ VGND VGND VPWR VPWR _0901_ sky130_fd_sc_hd__and2b_1
X_4728_ _2286_ VGND VGND VPWR VPWR _0259_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_16_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4659_ i_decode_stage.fetch_state_i\[19\] _2103_ _2234_ VGND VGND VPWR VPWR _2257_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_71_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_86_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_54_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_500 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_22_213 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_62_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_54_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3961_ net31 net17 i_exec_stage.exec_state_o\[8\] VGND VGND VPWR VPWR _1811_ sky130_fd_sc_hd__mux2_1
X_2912_ _0324_ _0326_ i_decode_stage.reg_meta_o\[18\] VGND VGND VPWR VPWR _0827_ sky130_fd_sc_hd__o21a_1
XFILLER_0_85_485 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3892_ _1195_ _1035_ _1767_ _0545_ _1768_ VGND VGND VPWR VPWR _1769_ sky130_fd_sc_hd__a221o_1
XFILLER_0_45_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_45_349 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2843_ i_decode_stage.reg_meta_o\[32\] _0727_ _0386_ _0757_ VGND VGND VPWR VPWR _0758_
+ sky130_fd_sc_hd__a211o_1
X_2774_ i_exec_stage.data_fwd_o\[5\] _0692_ _0460_ VGND VGND VPWR VPWR _0693_ sky130_fd_sc_hd__mux2_2
X_4513_ i_decode_stage.reg_meta_o\[28\] net113 _2179_ VGND VGND VPWR VPWR _2184_ sky130_fd_sc_hd__mux2_1
XFILLER_0_53_393 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_13_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4444_ net221 _2140_ VGND VGND VPWR VPWR _2145_ sky130_fd_sc_hd__and2_1
XFILLER_0_95_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4375_ net206 _1936_ _2045_ _2089_ VGND VGND VPWR VPWR _2090_ sky130_fd_sc_hd__a22o_1
X_3326_ _1215_ _1225_ _1229_ VGND VGND VPWR VPWR _1230_ sky130_fd_sc_hd__or3b_1
XTAP_430 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_441 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_452 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_463 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_474 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_485 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3257_ _0707_ _0691_ VGND VGND VPWR VPWR _1162_ sky130_fd_sc_hd__and2_1
XTAP_496 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3188_ _1088_ _1099_ VGND VGND VPWR VPWR _1100_ sky130_fd_sc_hd__nor2_1
XFILLER_0_95_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_68_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_63_113 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_91_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_32_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_393 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xclkbuf_leaf_18_clk_i clknet_2_3__leaf_clk_i VGND VGND VPWR VPWR clknet_leaf_18_clk_i
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_94_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_433 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_82_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_23_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput208 net208 VGND VGND VPWR VPWR imem_addr_o[17] sky130_fd_sc_hd__clkbuf_4
X_2490_ i_mem_slice_stage.mem_state_o\[43\] i_mem_slice_stage.mem_state_o\[4\] i_mem_slice_stage.mem_state_o\[36\]
+ VGND VGND VPWR VPWR _0440_ sky130_fd_sc_hd__mux2_2
Xoutput219 net219 VGND VGND VPWR VPWR imem_addr_o[27] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_50_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4160_ i_decode_stage.fetch_state_i\[16\] i_decode_stage.decode_state_o\[24\] _1936_
+ VGND VGND VPWR VPWR _1958_ sky130_fd_sc_hd__mux2_1
X_3111_ _0537_ _1022_ VGND VGND VPWR VPWR _1023_ sky130_fd_sc_hd__nor2_1
XFILLER_0_4_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4091_ _1890_ _1891_ i_decode_stage.decode_state_o\[241\] VGND VGND VPWR VPWR _1909_
+ sky130_fd_sc_hd__o21ba_1
X_3042_ _0936_ _0947_ _0948_ _0952_ _0953_ VGND VGND VPWR VPWR _0954_ sky130_fd_sc_hd__a221oi_2
XFILLER_0_81_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4993_ clknet_leaf_44_clk_i _0173_ net281 VGND VGND VPWR VPWR i_decode_stage.reg_meta_o\[54\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_58_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3944_ _0601_ _1799_ _1800_ _0917_ _1776_ VGND VGND VPWR VPWR net184 sky130_fd_sc_hd__a221o_1
X_3875_ _1198_ _1023_ VGND VGND VPWR VPWR _1753_ sky130_fd_sc_hd__nand2_1
XFILLER_0_45_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2826_ i_exec_stage.data_fwd_o\[29\] _0726_ _0740_ VGND VGND VPWR VPWR _0741_ sky130_fd_sc_hd__o21ai_4
XFILLER_0_60_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_60_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_5_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2757_ _0346_ i_decode_stage.decode_state_o\[130\] _0347_ _0676_ VGND VGND VPWR VPWR
+ _0677_ sky130_fd_sc_hd__a22oi_4
X_2688_ _0358_ _0611_ _0613_ _0614_ VGND VGND VPWR VPWR _0615_ sky130_fd_sc_hd__o31a_2
X_4427_ net218 _2125_ VGND VGND VPWR VPWR _2131_ sky130_fd_sc_hd__and2_1
X_4358_ _2075_ _2076_ VGND VGND VPWR VPWR _2077_ sky130_fd_sc_hd__nor2_1
XTAP_260 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3309_ _0430_ _1212_ VGND VGND VPWR VPWR _1213_ sky130_fd_sc_hd__or2_1
XTAP_293 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_282 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_271 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4289_ _2027_ VGND VGND VPWR VPWR _0079_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_64_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_17_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_36_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_10_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_32_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_32_352 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_87_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_113 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_51_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_82_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_488 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3660_ _0991_ _1527_ _0989_ VGND VGND VPWR VPWR _1549_ sky130_fd_sc_hd__o21bai_1
X_2611_ i_mem_slice_stage.mem_state_o\[66\] i_mem_slice_stage.mem_state_o\[27\] _0453_
+ VGND VGND VPWR VPWR _0547_ sky130_fd_sc_hd__mux2_2
XFILLER_0_23_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3591_ _0415_ _0852_ _1481_ _1483_ VGND VGND VPWR VPWR _1484_ sky130_fd_sc_hd__o211a_1
X_2542_ _0344_ _0478_ _0485_ VGND VGND VPWR VPWR _0486_ sky130_fd_sc_hd__a21o_1
XFILLER_0_2_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5261_ clknet_leaf_20_clk_i _0260_ net296 VGND VGND VPWR VPWR i_decode_stage.fetch_state_i\[59\]
+ sky130_fd_sc_hd__dfrtp_1
X_2473_ _0418_ _0413_ VGND VGND VPWR VPWR _0423_ sky130_fd_sc_hd__or2_1
X_4212_ i_decode_stage.decode_state_o\[49\] i_decode_stage.fetch_state_i\[41\] _1982_
+ VGND VGND VPWR VPWR _1985_ sky130_fd_sc_hd__mux2_1
X_5192_ clknet_leaf_27_clk_i net346 net290 VGND VGND VPWR VPWR i_mem_slice_stage.mem_state_o\[99\]
+ sky130_fd_sc_hd__dfrtp_2
X_4143_ _1949_ VGND VGND VPWR VPWR _0011_ sky130_fd_sc_hd__clkbuf_1
X_4074_ _1890_ _1891_ VGND VGND VPWR VPWR _1892_ sky130_fd_sc_hd__or2_1
X_3025_ _0913_ _0921_ _0936_ VGND VGND VPWR VPWR _0937_ sky130_fd_sc_hd__or3b_1
XFILLER_0_18_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4976_ clknet_leaf_10_clk_i _0156_ net292 VGND VGND VPWR VPWR i_decode_stage.reg_meta_o\[37\]
+ sky130_fd_sc_hd__dfrtp_1
X_3927_ _1790_ VGND VGND VPWR VPWR net176 sky130_fd_sc_hd__inv_2
XFILLER_0_46_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3858_ _0417_ _0532_ _0737_ _0424_ VGND VGND VPWR VPWR _1737_ sky130_fd_sc_hd__o22a_1
X_2809_ i_decode_stage.decode_state_o\[4\] i_decode_stage.decode_state_o\[3\] i_exec_stage.valid
+ VGND VGND VPWR VPWR net166 sky130_fd_sc_hd__o21a_1
XFILLER_0_61_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3789_ _0771_ _0779_ _0772_ VGND VGND VPWR VPWR _1671_ sky130_fd_sc_hd__o21a_1
XFILLER_0_14_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_193 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xfanout287 net291 VGND VGND VPWR VPWR net287 sky130_fd_sc_hd__buf_12
XFILLER_0_56_219 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_64_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_24_127 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_52_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_20_344 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_87_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4830_ clknet_leaf_43_clk_i _0010_ net280 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[14\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_47_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_87_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4761_ i_exec_stage.data_fwd_o\[11\] net132 _1839_ VGND VGND VPWR VPWR _2303_ sky130_fd_sc_hd__mux2_1
X_4692_ _2268_ VGND VGND VPWR VPWR _0241_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_7_349 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3712_ _0797_ _0798_ VGND VGND VPWR VPWR _1598_ sky130_fd_sc_hd__or2_1
X_3643_ _1129_ _1127_ _1479_ VGND VGND VPWR VPWR _1533_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_70_277 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3574_ _0852_ _0942_ _1464_ VGND VGND VPWR VPWR _1467_ sky130_fd_sc_hd__or3_1
X_2525_ _0465_ _0470_ VGND VGND VPWR VPWR _0471_ sky130_fd_sc_hd__and2_1
XFILLER_0_87_98 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2456_ _0345_ _0382_ _0405_ VGND VGND VPWR VPWR _0406_ sky130_fd_sc_hd__or3_1
X_5244_ clknet_leaf_31_clk_i _0243_ net285 VGND VGND VPWR VPWR i_decode_stage.fetch_state_i\[42\]
+ sky130_fd_sc_hd__dfrtp_1
Xhold29 i_exec_stage.exec_state_o\[45\] VGND VGND VPWR VPWR net366 sky130_fd_sc_hd__clkdlybuf4s25_1
X_5175_ clknet_leaf_30_clk_i net372 net285 VGND VGND VPWR VPWR i_mem_slice_stage.mem_state_o\[82\]
+ sky130_fd_sc_hd__dfrtp_1
Xhold18 i_decode_stage.decode_state_o\[32\] VGND VGND VPWR VPWR net355 sky130_fd_sc_hd__clkdlybuf4s25_1
X_4126_ i_decode_stage.decode_state_o\[5\] _1928_ _1935_ _1940_ VGND VGND VPWR VPWR
+ _0003_ sky130_fd_sc_hd__a211o_1
X_2387_ _0338_ i_decode_stage.decode_state_o\[147\] i_decode_stage.decode_state_o\[40\]
+ _0339_ _2332_ VGND VGND VPWR VPWR _0340_ sky130_fd_sc_hd__a221o_1
XFILLER_0_36_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4057_ _0630_ _0925_ _1869_ _0655_ VGND VGND VPWR VPWR _1875_ sky130_fd_sc_hd__a22o_1
Xcore_309 VGND VGND VPWR VPWR core_309/HI imem_wdata_o[5] sky130_fd_sc_hd__conb_1
XFILLER_0_78_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3008_ _0650_ _0919_ VGND VGND VPWR VPWR _0920_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_78_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_93_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4959_ clknet_leaf_3_clk_i _0139_ net283 VGND VGND VPWR VPWR i_decode_stage.reg_meta_o\[20\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_34_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_61_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_14_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_69_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_1031 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1020 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_1064 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1053 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1042 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_32_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1097 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1086 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1075 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3290_ _0413_ VGND VGND VPWR VPWR _1195_ sky130_fd_sc_hd__inv_2
XTAP_804 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_815 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_826 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_837 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_848 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_859 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_90_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_7_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4813_ i_exec_stage.data_fwd_o\[37\] i_decode_stage.decode_state_o\[140\] _1838_
+ VGND VGND VPWR VPWR _2329_ sky130_fd_sc_hd__mux2_1
X_4744_ _2294_ VGND VGND VPWR VPWR _0267_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_16_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4675_ _2260_ VGND VGND VPWR VPWR _0232_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_101_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3626_ _0344_ _0512_ _0623_ VGND VGND VPWR VPWR _1517_ sky130_fd_sc_hd__a21o_1
X_3557_ _0707_ _1272_ _1322_ VGND VGND VPWR VPWR _1451_ sky130_fd_sc_hd__o21a_1
XFILLER_0_3_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_101_349 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2508_ i_mem_slice_stage.mem_state_o\[94\] _0452_ _0454_ _0455_ VGND VGND VPWR VPWR
+ net257 sky130_fd_sc_hd__a22o_1
X_5227_ clknet_leaf_28_clk_i _0226_ net290 VGND VGND VPWR VPWR i_decode_stage.fetch_state_i\[25\]
+ sky130_fd_sc_hd__dfrtp_1
Xinput108 rf_rs2_i[18] VGND VGND VPWR VPWR net108 sky130_fd_sc_hd__clkbuf_1
X_3488_ _0948_ _1377_ _0952_ VGND VGND VPWR VPWR _1385_ sky130_fd_sc_hd__o21ai_1
X_2439_ i_exec_stage.data_fwd_o\[2\] _0311_ _0316_ _0320_ VGND VGND VPWR VPWR _0390_
+ sky130_fd_sc_hd__or4_1
Xinput119 rf_rs2_i[28] VGND VGND VPWR VPWR net119 sky130_fd_sc_hd__clkbuf_1
X_5158_ clknet_leaf_12_clk_i net345 net297 VGND VGND VPWR VPWR i_mem_slice_stage.mem_state_o\[65\]
+ sky130_fd_sc_hd__dfrtp_1
X_5089_ clknet_leaf_28_clk_i i_decode_stage.decode_state_o\[33\] net291 VGND VGND
+ VPWR VPWR i_exec_stage.exec_state_o\[64\] sky130_fd_sc_hd__dfrtp_1
X_4109_ net33 net66 _0720_ VGND VGND VPWR VPWR _1926_ sky130_fd_sc_hd__nand3_4
XPHY_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_81 net150 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_92 net278 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_70 net41 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_97_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_43_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_5 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_84_177 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2790_ _0384_ net193 _0446_ VGND VGND VPWR VPWR _0709_ sky130_fd_sc_hd__o21ai_4
XFILLER_0_80_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_417 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_7_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4460_ net64 i_decode_stage.decode_state_o\[137\] _1967_ VGND VGND VPWR VPWR _2157_
+ sky130_fd_sc_hd__mux2_1
X_3411_ _1182_ _1178_ _0525_ VGND VGND VPWR VPWR _1312_ sky130_fd_sc_hd__mux2_1
X_4391_ net209 _2095_ net210 VGND VGND VPWR VPWR _2102_ sky130_fd_sc_hd__a21oi_1
X_3342_ _1087_ _1238_ _1242_ _1244_ VGND VGND VPWR VPWR _1245_ sky130_fd_sc_hd__a211o_1
XFILLER_0_0_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_0_377 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_601 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_612 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_623 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_634 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3273_ _0558_ _0538_ _0527_ VGND VGND VPWR VPWR _1178_ sky130_fd_sc_hd__mux2_1
XTAP_645 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_656 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_667 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5012_ clknet_leaf_2_clk_i _0192_ net283 VGND VGND VPWR VPWR i_decode_stage.reg_meta_o\[73\]
+ sky130_fd_sc_hd__dfrtp_1
XTAP_678 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_689 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_60 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_75_122 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_75_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_8_433 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_8_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2988_ _0709_ _0695_ _0898_ _0899_ VGND VGND VPWR VPWR _0900_ sky130_fd_sc_hd__a31o_1
X_4727_ net218 i_decode_stage.fetch_state_i\[58\] _1927_ VGND VGND VPWR VPWR _2286_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_71_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_31_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4658_ _2256_ VGND VGND VPWR VPWR _0219_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_101_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3609_ _0448_ _1421_ VGND VGND VPWR VPWR _1501_ sky130_fd_sc_hd__nand2_2
Xinput90 rf_rs1_i[30] VGND VGND VPWR VPWR net90 sky130_fd_sc_hd__clkbuf_1
X_4589_ _2222_ VGND VGND VPWR VPWR _0184_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_79_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_94_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_339 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_81_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_22_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_50_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_15 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_89_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3960_ i_exec_stage.exec_state_o\[1\] _1805_ VGND VGND VPWR VPWR _1810_ sky130_fd_sc_hd__nor2b_4
XFILLER_0_85_431 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_18_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2911_ _2336_ _2341_ net245 VGND VGND VPWR VPWR _0826_ sky130_fd_sc_hd__and3_1
X_3891_ _0424_ _1032_ VGND VGND VPWR VPWR _1768_ sky130_fd_sc_hd__nor2_1
XFILLER_0_85_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_38_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2842_ _2336_ _2341_ net260 VGND VGND VPWR VPWR _0757_ sky130_fd_sc_hd__and3_1
XFILLER_0_5_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2773_ net268 i_decode_stage.reg_meta_o\[48\] _0457_ VGND VGND VPWR VPWR _0692_ sky130_fd_sc_hd__mux2_1
X_4512_ _2183_ VGND VGND VPWR VPWR _0146_ sky130_fd_sc_hd__clkbuf_1
X_4443_ net151 _1924_ VGND VGND VPWR VPWR _2144_ sky130_fd_sc_hd__or2_1
X_4374_ net206 _2085_ VGND VGND VPWR VPWR _2089_ sky130_fd_sc_hd__xor2_1
XFILLER_0_0_141 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_95_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3325_ _1226_ _1196_ _1227_ _1228_ _1158_ VGND VGND VPWR VPWR _1229_ sky130_fd_sc_hd__a311o_1
XTAP_420 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_431 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_442 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3256_ _0887_ _0889_ _0892_ _0894_ VGND VGND VPWR VPWR _1161_ sky130_fd_sc_hd__o31a_1
XTAP_453 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_464 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_475 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_486 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_497 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3187_ _0523_ _1095_ _1096_ _1098_ VGND VGND VPWR VPWR _1099_ sky130_fd_sc_hd__o22a_1
XFILLER_0_95_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_91_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_48_155 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_29_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_44_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_44_372 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_86_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_420 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_94_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_82_445 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_40_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_489 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xoutput209 net209 VGND VGND VPWR VPWR imem_addr_o[18] sky130_fd_sc_hd__buf_2
X_3110_ _0384_ _1020_ _1021_ _0752_ VGND VGND VPWR VPWR _1022_ sky130_fd_sc_hd__o211a_1
X_4090_ _1904_ _1895_ _1907_ _1890_ VGND VGND VPWR VPWR _1908_ sky130_fd_sc_hd__a31o_1
X_3041_ _0633_ _0927_ VGND VGND VPWR VPWR _0953_ sky130_fd_sc_hd__nor2_1
XFILLER_0_81_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4992_ clknet_leaf_0_clk_i _0172_ net281 VGND VGND VPWR VPWR i_decode_stage.reg_meta_o\[53\]
+ sky130_fd_sc_hd__dfrtp_1
X_3943_ i_decode_stage.decode_state_o\[0\] _1110_ VGND VGND VPWR VPWR _1800_ sky130_fd_sc_hd__and2_1
X_3874_ _0448_ _1452_ VGND VGND VPWR VPWR _1752_ sky130_fd_sc_hd__nor2_1
XFILLER_0_14_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_5_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2825_ i_decode_stage.reg_meta_o\[34\] _0727_ _0386_ _0739_ VGND VGND VPWR VPWR _0740_
+ sky130_fd_sc_hd__a211o_1
XFILLER_0_14_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2756_ i_exec_stage.data_fwd_o\[7\] _0675_ _0460_ VGND VGND VPWR VPWR _0676_ sky130_fd_sc_hd__mux2_4
X_2687_ i_exec_stage.data_fwd_o\[16\] _0352_ _0355_ _0357_ VGND VGND VPWR VPWR _0614_
+ sky130_fd_sc_hd__or4_1
XFILLER_0_1_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4426_ _1688_ _2129_ VGND VGND VPWR VPWR _2130_ sky130_fd_sc_hd__nand2_1
X_4357_ net202 _2071_ VGND VGND VPWR VPWR _2076_ sky130_fd_sc_hd__nor2_1
XTAP_250 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3308_ _0886_ _0896_ VGND VGND VPWR VPWR _1212_ sky130_fd_sc_hd__nor2_1
XTAP_283 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_272 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_261 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4288_ _1933_ _2026_ VGND VGND VPWR VPWR _2027_ sky130_fd_sc_hd__or2_1
X_3239_ _0343_ _0382_ _0405_ _0420_ VGND VGND VPWR VPWR _1145_ sky130_fd_sc_hd__o31a_1
XTAP_294 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_76_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_489 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_44_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_35_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_70_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_70_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2610_ _0540_ _0545_ VGND VGND VPWR VPWR _0546_ sky130_fd_sc_hd__nand2_1
X_3590_ _0417_ _0617_ _0851_ _0419_ _1482_ VGND VGND VPWR VPWR _1483_ sky130_fd_sc_hd__o221a_1
X_2541_ _0465_ _0484_ VGND VGND VPWR VPWR _0485_ sky130_fd_sc_hd__and2_1
X_2472_ _0421_ VGND VGND VPWR VPWR _0422_ sky130_fd_sc_hd__buf_8
X_5260_ clknet_leaf_26_clk_i _0259_ net289 VGND VGND VPWR VPWR i_decode_stage.fetch_state_i\[58\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_50_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4211_ _1984_ VGND VGND VPWR VPWR _0044_ sky130_fd_sc_hd__clkbuf_1
X_5191_ clknet_leaf_27_clk_i net380 net290 VGND VGND VPWR VPWR i_mem_slice_stage.mem_state_o\[98\]
+ sky130_fd_sc_hd__dfrtp_2
X_4142_ i_decode_stage.fetch_state_i\[7\] i_decode_stage.decode_state_o\[15\] _1936_
+ VGND VGND VPWR VPWR _1949_ sky130_fd_sc_hd__mux2_1
X_4073_ _0543_ _1030_ VGND VGND VPWR VPWR _1891_ sky130_fd_sc_hd__and2_1
X_3024_ _0928_ _0935_ VGND VGND VPWR VPWR _0936_ sky130_fd_sc_hd__nor2_1
X_4975_ clknet_leaf_10_clk_i _0155_ net292 VGND VGND VPWR VPWR i_decode_stage.reg_meta_o\[36\]
+ sky130_fd_sc_hd__dfrtp_1
X_3926_ _0519_ _0986_ _0601_ VGND VGND VPWR VPWR _1790_ sky130_fd_sc_hd__mux2_1
X_3857_ _1313_ _1435_ VGND VGND VPWR VPWR _1736_ sky130_fd_sc_hd__nor2_1
XFILLER_0_18_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2808_ _0724_ VGND VGND VPWR VPWR i_exec_stage.valid sky130_fd_sc_hd__dlymetal6s2s_1
X_3788_ _0771_ _0779_ _1638_ _0772_ _0764_ VGND VGND VPWR VPWR _1670_ sky130_fd_sc_hd__o311a_1
X_2739_ _0525_ VGND VGND VPWR VPWR _0662_ sky130_fd_sc_hd__buf_8
X_4409_ net215 _2112_ VGND VGND VPWR VPWR _2116_ sky130_fd_sc_hd__nor2_1
Xfanout288 net291 VGND VGND VPWR VPWR net288 sky130_fd_sc_hd__buf_6
XFILLER_0_24_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4760_ _2302_ VGND VGND VPWR VPWR _0275_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_28_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4691_ net230 i_decode_stage.fetch_state_i\[40\] _1967_ VGND VGND VPWR VPWR _2268_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_43_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3711_ _0411_ _1585_ _1594_ _1597_ VGND VGND VPWR VPWR net143 sky130_fd_sc_hd__a211o_4
X_3642_ _0991_ _0996_ _1529_ _1531_ VGND VGND VPWR VPWR _1532_ sky130_fd_sc_hd__o31a_1
X_3573_ _0411_ _1447_ _1463_ _1466_ VGND VGND VPWR VPWR net136 sky130_fd_sc_hd__a211o_4
XFILLER_0_70_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2524_ _0451_ _0468_ _0462_ _0469_ VGND VGND VPWR VPWR _0470_ sky130_fd_sc_hd__a2bb2o_4
X_2455_ _0394_ _0404_ VGND VGND VPWR VPWR _0405_ sky130_fd_sc_hd__xnor2_4
X_5243_ clknet_leaf_38_clk_i _0242_ net131 VGND VGND VPWR VPWR i_decode_stage.fetch_state_i\[41\]
+ sky130_fd_sc_hd__dfrtp_1
X_5174_ clknet_leaf_42_clk_i net400 net281 VGND VGND VPWR VPWR i_mem_slice_stage.mem_state_o\[81\]
+ sky130_fd_sc_hd__dfrtp_1
Xhold19 i_decode_stage.decode_state_o\[20\] VGND VGND VPWR VPWR net356 sky130_fd_sc_hd__clkdlybuf4s25_1
X_2386_ _0337_ _0338_ VGND VGND VPWR VPWR _0339_ sky130_fd_sc_hd__nor2_8
X_4125_ _1936_ _1939_ VGND VGND VPWR VPWR _1940_ sky130_fd_sc_hd__nor2_1
X_4056_ _0638_ _0829_ _0838_ _0600_ VGND VGND VPWR VPWR _1874_ sky130_fd_sc_hd__a22o_1
X_3007_ _2333_ _0917_ _0918_ VGND VGND VPWR VPWR _0919_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_78_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4958_ clknet_leaf_4_clk_i _0138_ net283 VGND VGND VPWR VPWR i_decode_stage.reg_meta_o\[19\]
+ sky130_fd_sc_hd__dfrtp_1
X_4889_ clknet_leaf_16_clk_i _0069_ net295 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[117\]
+ sky130_fd_sc_hd__dfrtp_1
X_3909_ _1778_ _1774_ _1779_ VGND VGND VPWR VPWR net169 sky130_fd_sc_hd__a21o_1
XFILLER_0_61_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_1021 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1010 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1065 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1054 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1043 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1032 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1098 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1087 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1076 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_4_309 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_805 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_816 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_827 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_838 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_849 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_73_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_73_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_87_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4812_ _2328_ VGND VGND VPWR VPWR _0301_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_83_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_7_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_28_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4743_ i_exec_stage.data_fwd_o\[2\] i_exec_stage.alu_out\[1\] _1839_ VGND VGND VPWR
+ VPWR _2294_ sky130_fd_sc_hd__mux2_1
XFILLER_0_71_510 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_7_169 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_22_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4674_ i_decode_stage.fetch_state_i\[31\] _2154_ _2234_ VGND VGND VPWR VPWR _2260_
+ sky130_fd_sc_hd__mux2_1
X_3625_ _0424_ _1515_ _0965_ VGND VGND VPWR VPWR _1516_ sky130_fd_sc_hd__a21o_1
X_3556_ _0707_ _1288_ _1449_ _1129_ VGND VGND VPWR VPWR _1450_ sky130_fd_sc_hd__o211a_1
X_2507_ _0330_ VGND VGND VPWR VPWR _0455_ sky130_fd_sc_hd__buf_4
X_5226_ clknet_leaf_26_clk_i _0225_ net289 VGND VGND VPWR VPWR i_decode_stage.fetch_state_i\[24\]
+ sky130_fd_sc_hd__dfrtp_1
Xinput109 rf_rs2_i[19] VGND VGND VPWR VPWR net109 sky130_fd_sc_hd__clkbuf_1
X_3487_ _0952_ _0948_ _1377_ VGND VGND VPWR VPWR _1384_ sky130_fd_sc_hd__or3_1
X_2438_ _0324_ _0326_ i_decode_stage.reg_meta_o\[7\] VGND VGND VPWR VPWR _0389_ sky130_fd_sc_hd__o21a_1
X_5157_ clknet_leaf_12_clk_i net368 net294 VGND VGND VPWR VPWR i_mem_slice_stage.mem_state_o\[64\]
+ sky130_fd_sc_hd__dfrtp_1
X_2369_ _2334_ _2335_ VGND VGND VPWR VPWR _0323_ sky130_fd_sc_hd__or2_1
XFILLER_0_47_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4108_ _1839_ i_decode_stage.valid_i _1840_ _1924_ _1925_ VGND VGND VPWR VPWR _0000_
+ sky130_fd_sc_hd__a41o_1
X_5088_ clknet_leaf_26_clk_i net355 net289 VGND VGND VPWR VPWR i_exec_stage.exec_state_o\[63\]
+ sky130_fd_sc_hd__dfrtp_1
X_4039_ _1853_ _1856_ VGND VGND VPWR VPWR _1857_ sky130_fd_sc_hd__nand2_1
XPHY_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_93_189 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_93_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_93 net278 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_71 net41 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_60 _0612_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_82 net153 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_30_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_27_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_97_473 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_57_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_84_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_13_429 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4390_ net209 net210 _2095_ VGND VGND VPWR VPWR _2101_ sky130_fd_sc_hd__and3_1
XFILLER_0_40_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3410_ _0876_ _0901_ _1261_ VGND VGND VPWR VPWR _1311_ sky130_fd_sc_hd__or3_1
X_3341_ _0660_ _0685_ _1243_ VGND VGND VPWR VPWR _1244_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_21_473 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_0_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_602 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_613 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_624 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3272_ _0540_ _0586_ VGND VGND VPWR VPWR _1177_ sky130_fd_sc_hd__nor2_1
XTAP_635 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_646 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_657 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_668 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5011_ clknet_leaf_2_clk_i _0191_ net283 VGND VGND VPWR VPWR i_decode_stage.reg_meta_o\[72\]
+ sky130_fd_sc_hd__dfrtp_1
XTAP_679 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_75_134 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_33_60 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_48_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_8_445 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_99_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_8_489 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2987_ _0683_ _0866_ VGND VGND VPWR VPWR _0899_ sky130_fd_sc_hd__and2b_1
X_4726_ _2285_ VGND VGND VPWR VPWR _0258_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_31_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4657_ i_decode_stage.fetch_state_i\[18\] _2099_ _2234_ VGND VGND VPWR VPWR _2256_
+ sky130_fd_sc_hd__mux2_1
X_3608_ _1204_ _1045_ _1498_ _0707_ _1499_ VGND VGND VPWR VPWR _1500_ sky130_fd_sc_hd__o221a_1
Xinput80 rf_rs1_i[21] VGND VGND VPWR VPWR net80 sky130_fd_sc_hd__clkbuf_1
Xinput91 rf_rs1_i[31] VGND VGND VPWR VPWR net91 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_101_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4588_ i_decode_stage.reg_meta_o\[65\] net80 _2207_ VGND VGND VPWR VPWR _2222_ sky130_fd_sc_hd__mux2_1
XFILLER_0_101_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3539_ _1357_ _1433_ _0523_ VGND VGND VPWR VPWR _1434_ sky130_fd_sc_hd__mux2_1
X_5209_ clknet_leaf_41_clk_i _0208_ net281 VGND VGND VPWR VPWR i_decode_stage.fetch_state_i\[7\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_94_421 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_94_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_473 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_66_145 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_62_340 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_62_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_85_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2910_ _0800_ _0809_ _0817_ _0824_ VGND VGND VPWR VPWR _0825_ sky130_fd_sc_hd__a31o_1
X_3890_ _0419_ _1032_ _0416_ VGND VGND VPWR VPWR _1767_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_70_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2841_ _0754_ _0755_ VGND VGND VPWR VPWR _0756_ sky130_fd_sc_hd__and2_1
X_2772_ _0450_ _0689_ _0690_ VGND VGND VPWR VPWR _0691_ sky130_fd_sc_hd__o21a_4
XFILLER_0_85_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_79_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_13_204 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4511_ i_decode_stage.reg_meta_o\[27\] net112 _2179_ VGND VGND VPWR VPWR _2183_ sky130_fd_sc_hd__mux2_1
XFILLER_0_80_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4442_ net220 _1928_ _2139_ _2143_ VGND VGND VPWR VPWR _0116_ sky130_fd_sc_hd__a22o_1
X_4373_ net136 _2042_ _2045_ _2087_ _2088_ VGND VGND VPWR VPWR _0102_ sky130_fd_sc_hd__a221o_1
XFILLER_0_0_153 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_21_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3324_ _1196_ _1227_ _1226_ VGND VGND VPWR VPWR _1228_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_0_197 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_410 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_421 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_432 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3255_ _1143_ _1147_ _1151_ _1160_ VGND VGND VPWR VPWR net152 sky130_fd_sc_hd__nand4_4
XTAP_443 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_454 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_465 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_476 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_487 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_498 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3186_ _0422_ _1097_ _0523_ VGND VGND VPWR VPWR _1098_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_95_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_76_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_44_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_63_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_17_510 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4709_ net208 i_decode_stage.fetch_state_i\[49\] _1927_ VGND VGND VPWR VPWR _2277_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_44_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_8_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_39_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_82_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_82_457 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_50_365 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3040_ _0950_ _0951_ VGND VGND VPWR VPWR _0952_ sky130_fd_sc_hd__nand2_1
X_4991_ clknet_leaf_43_clk_i _0171_ net280 VGND VGND VPWR VPWR i_decode_stage.reg_meta_o\[52\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_58_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3942_ _0768_ VGND VGND VPWR VPWR _1799_ sky130_fd_sc_hd__inv_2
XFILLER_0_85_284 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3873_ _0709_ _1451_ _1479_ VGND VGND VPWR VPWR _1751_ sky130_fd_sc_hd__a21oi_1
X_2824_ _2336_ _2341_ net262 VGND VGND VPWR VPWR _0739_ sky130_fd_sc_hd__and3_1
XFILLER_0_73_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2755_ net270 i_decode_stage.reg_meta_o\[50\] _0457_ VGND VGND VPWR VPWR _0675_ sky130_fd_sc_hd__mux2_1
XFILLER_0_30_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2686_ _0363_ _0369_ _0374_ net248 VGND VGND VPWR VPWR _0613_ sky130_fd_sc_hd__and4_1
XFILLER_0_30_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4425_ _1924_ VGND VGND VPWR VPWR _2129_ sky130_fd_sc_hd__inv_2
X_4356_ net231 net201 net202 _2065_ VGND VGND VPWR VPWR _2075_ sky130_fd_sc_hd__and4_1
XFILLER_0_1_473 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3307_ _1209_ _1210_ _0885_ VGND VGND VPWR VPWR _1211_ sky130_fd_sc_hd__a21oi_1
XTAP_240 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_251 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_284 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_273 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_262 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4287_ i_decode_stage.decode_state_o\[233\] _2022_ _0722_ VGND VGND VPWR VPWR _2026_
+ sky130_fd_sc_hd__mux2_1
X_3238_ i_decode_stage.decode_state_o\[237\] _0413_ VGND VGND VPWR VPWR _1144_ sky130_fd_sc_hd__nor2_4
XTAP_295 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3169_ _0343_ _0672_ _1080_ VGND VGND VPWR VPWR _1081_ sky130_fd_sc_hd__a21o_1
XFILLER_0_76_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_91_210 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_71_90 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_91_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_32_365 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_19_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_35_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_82_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_51_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_55_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_35_181 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_11_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2540_ _0451_ _0481_ _0483_ VGND VGND VPWR VPWR _0484_ sky130_fd_sc_hd__o21ai_4
X_2471_ _0394_ VGND VGND VPWR VPWR _0421_ sky130_fd_sc_hd__clkbuf_16
X_4210_ i_decode_stage.decode_state_o\[48\] i_decode_stage.fetch_state_i\[40\] _1982_
+ VGND VGND VPWR VPWR _1984_ sky130_fd_sc_hd__mux2_1
X_5190_ clknet_leaf_27_clk_i net373 net289 VGND VGND VPWR VPWR i_mem_slice_stage.mem_state_o\[97\]
+ sky130_fd_sc_hd__dfrtp_2
X_4141_ _1948_ VGND VGND VPWR VPWR _0010_ sky130_fd_sc_hd__clkbuf_1
Xclkbuf_0_clk_i clk_i VGND VGND VPWR VPWR clknet_0_clk_i sky130_fd_sc_hd__clkbuf_16
X_4072_ _0543_ _1030_ VGND VGND VPWR VPWR _1890_ sky130_fd_sc_hd__nor2_1
X_3023_ _0656_ _0934_ VGND VGND VPWR VPWR _0935_ sky130_fd_sc_hd__xor2_4
X_4974_ clknet_leaf_10_clk_i _0154_ net292 VGND VGND VPWR VPWR i_decode_stage.reg_meta_o\[35\]
+ sky130_fd_sc_hd__dfrtp_1
X_3925_ _1789_ VGND VGND VPWR VPWR net175 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_73_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_73_232 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3856_ _1326_ _1588_ _1734_ _1041_ _1441_ VGND VGND VPWR VPWR _1735_ sky130_fd_sc_hd__o221a_1
XFILLER_0_33_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_81_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_14_321 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_33_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2807_ i_decode_stage.valid_o _0722_ VGND VGND VPWR VPWR _0724_ sky130_fd_sc_hd__and2_1
XFILLER_0_61_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3787_ _1156_ _1655_ _1656_ _1660_ _1669_ VGND VGND VPWR VPWR net147 sky130_fd_sc_hd__a311o_4
X_2738_ _0625_ _0659_ _0660_ VGND VGND VPWR VPWR _0661_ sky130_fd_sc_hd__mux2_1
XFILLER_0_14_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2669_ _0376_ _0377_ _0378_ i_decode_stage.reg_meta_o\[57\] VGND VGND VPWR VPWR _0598_
+ sky130_fd_sc_hd__o31a_1
X_4408_ net214 _1929_ _2115_ VGND VGND VPWR VPWR _0110_ sky130_fd_sc_hd__a21o_1
XFILLER_0_1_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4339_ net158 _2047_ _2048_ _2061_ _2062_ VGND VGND VPWR VPWR _0094_ sky130_fd_sc_hd__o221a_1
XFILLER_0_5_60 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xfanout289 net290 VGND VGND VPWR VPWR net289 sky130_fd_sc_hd__buf_12
XFILLER_0_69_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_96_368 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_96_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_265 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_20_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_20_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_20_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_46_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3710_ _0809_ _1595_ _1596_ VGND VGND VPWR VPWR _1597_ sky130_fd_sc_hd__o21a_1
XFILLER_0_15_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4690_ _2267_ VGND VGND VPWR VPWR _0240_ sky130_fd_sc_hd__clkbuf_1
X_3641_ _0430_ _1530_ VGND VGND VPWR VPWR _1531_ sky130_fd_sc_hd__nor2_1
X_3572_ _1464_ _1465_ _1156_ VGND VGND VPWR VPWR _1466_ sky130_fd_sc_hd__and3b_1
X_2523_ _0346_ i_decode_stage.decode_state_o\[128\] VGND VGND VPWR VPWR _0469_ sky130_fd_sc_hd__or2b_1
XFILLER_0_11_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5242_ clknet_leaf_38_clk_i _0241_ net285 VGND VGND VPWR VPWR i_decode_stage.fetch_state_i\[40\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_53_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2454_ _0347_ _0402_ _0403_ _0346_ VGND VGND VPWR VPWR _0404_ sky130_fd_sc_hd__a22oi_4
X_5173_ clknet_leaf_42_clk_i net381 net281 VGND VGND VPWR VPWR i_mem_slice_stage.mem_state_o\[80\]
+ sky130_fd_sc_hd__dfrtp_1
X_2385_ i_decode_stage.decode_state_o\[232\] VGND VGND VPWR VPWR _0338_ sky130_fd_sc_hd__inv_2
X_4124_ _1937_ _1938_ VGND VGND VPWR VPWR _1939_ sky130_fd_sc_hd__nand2_1
Xinput1 dmem_rdata_i[0] VGND VGND VPWR VPWR net1 sky130_fd_sc_hd__clkbuf_1
X_4055_ _0671_ _0908_ _1868_ _0649_ VGND VGND VPWR VPWR _1873_ sky130_fd_sc_hd__a22o_1
X_3006_ i_decode_stage.decode_state_o\[49\] _0339_ _0751_ i_decode_stage.decode_state_o\[133\]
+ VGND VGND VPWR VPWR _0918_ sky130_fd_sc_hd__a22o_1
XFILLER_0_19_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4957_ clknet_leaf_3_clk_i _0137_ net283 VGND VGND VPWR VPWR i_decode_stage.reg_meta_o\[18\]
+ sky130_fd_sc_hd__dfrtp_1
X_4888_ clknet_leaf_16_clk_i _0068_ net295 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[0\]
+ sky130_fd_sc_hd__dfrtp_4
X_3908_ _0578_ _1774_ VGND VGND VPWR VPWR _1779_ sky130_fd_sc_hd__nor2_1
X_3839_ _0422_ _1718_ _0525_ VGND VGND VPWR VPWR _1719_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_69_313 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1022 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1011 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1000 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1055 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1044 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1033 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_32_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_1099 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1088 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1077 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1066 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_405 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_25_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_40_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_806 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_817 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_828 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_839 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_16_clk_i clknet_2_2__leaf_clk_i VGND VGND VPWR VPWR clknet_leaf_16_clk_i
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_87_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_87_132 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_87_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4811_ i_exec_stage.data_fwd_o\[36\] i_decode_stage.decode_state_o\[139\] _1838_
+ VGND VGND VPWR VPWR _2328_ sky130_fd_sc_hd__mux2_1
XFILLER_0_75_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_16_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4742_ _2293_ VGND VGND VPWR VPWR _0266_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_22_62 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4673_ i_decode_stage.fetch_state_i\[30\] _1929_ _2152_ VGND VGND VPWR VPWR _0231_
+ sky130_fd_sc_hd__a21o_1
X_3624_ _0417_ _0512_ _0964_ _0413_ _1514_ VGND VGND VPWR VPWR _1515_ sky130_fd_sc_hd__o221a_1
X_3555_ _0707_ _1273_ VGND VGND VPWR VPWR _1449_ sky130_fd_sc_hd__nand2_1
XFILLER_0_11_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2506_ i_mem_slice_stage.mem_state_o\[62\] i_mem_slice_stage.mem_state_o\[23\] _0453_
+ VGND VGND VPWR VPWR _0454_ sky130_fd_sc_hd__mux2_2
XFILLER_0_11_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3486_ _0411_ _1367_ _1376_ _1383_ VGND VGND VPWR VPWR net132 sky130_fd_sc_hd__a211o_4
XFILLER_0_11_187 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5225_ clknet_leaf_24_clk_i _0224_ net287 VGND VGND VPWR VPWR i_decode_stage.fetch_state_i\[23\]
+ sky130_fd_sc_hd__dfrtp_1
X_2437_ _2336_ _2341_ net253 VGND VGND VPWR VPWR _0388_ sky130_fd_sc_hd__and3_1
X_5156_ clknet_leaf_15_clk_i net367 net295 VGND VGND VPWR VPWR i_mem_slice_stage.mem_state_o\[63\]
+ sky130_fd_sc_hd__dfrtp_1
X_2368_ _0321_ VGND VGND VPWR VPWR _0322_ sky130_fd_sc_hd__buf_4
X_5087_ clknet_leaf_23_clk_i net409 net288 VGND VGND VPWR VPWR i_exec_stage.exec_state_o\[62\]
+ sky130_fd_sc_hd__dfrtp_1
X_4107_ _1839_ _1840_ i_decode_stage.valid_o VGND VGND VPWR VPWR _1925_ sky130_fd_sc_hd__a21boi_1
X_4038_ _0519_ _0701_ _1854_ _1855_ VGND VGND VPWR VPWR _1856_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_0_93_113 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_81_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_50 net211 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_34_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_72 net46 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_61 _0612_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_83 net156 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_22_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput190 net190 VGND VGND VPWR VPWR dmem_wdata_o[30] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_97_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_97_485 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_53_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_25_268 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_80_374 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_33_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3340_ _0662_ _0659_ _1088_ VGND VGND VPWR VPWR _1243_ sky130_fd_sc_hd__a21o_1
XFILLER_0_21_485 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_603 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_614 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_625 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3271_ _0662_ _1173_ _1174_ _1175_ _0707_ VGND VGND VPWR VPWR _1176_ sky130_fd_sc_hd__a221o_1
X_5010_ clknet_leaf_1_clk_i _0190_ net283 VGND VGND VPWR VPWR i_decode_stage.reg_meta_o\[71\]
+ sky130_fd_sc_hd__dfrtp_1
XTAP_636 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_647 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_658 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_669 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_441 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_16_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_75_146 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_75_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_90_127 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2986_ _0683_ _0866_ VGND VGND VPWR VPWR _0898_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_16_224 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_8_457 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_44_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_56_382 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4725_ net217 i_decode_stage.fetch_state_i\[57\] _1927_ VGND VGND VPWR VPWR _2285_
+ sky130_fd_sc_hd__mux2_1
X_4656_ _2255_ VGND VGND VPWR VPWR _0218_ sky130_fd_sc_hd__clkbuf_1
X_3607_ _0707_ _1330_ VGND VGND VPWR VPWR _1499_ sky130_fd_sc_hd__nand2_1
Xinput70 rf_rs1_i[12] VGND VGND VPWR VPWR net70 sky130_fd_sc_hd__clkbuf_1
Xinput81 rf_rs1_i[22] VGND VGND VPWR VPWR net81 sky130_fd_sc_hd__clkbuf_1
X_4587_ _2221_ VGND VGND VPWR VPWR _0183_ sky130_fd_sc_hd__clkbuf_1
X_3538_ _1388_ _1432_ _0421_ VGND VGND VPWR VPWR _1433_ sky130_fd_sc_hd__mux2_1
Xinput92 rf_rs1_i[3] VGND VGND VPWR VPWR net92 sky130_fd_sc_hd__clkbuf_1
X_3469_ _0935_ _1366_ VGND VGND VPWR VPWR _1367_ sky130_fd_sc_hd__xor2_1
X_5208_ clknet_leaf_41_clk_i _0207_ net282 VGND VGND VPWR VPWR i_decode_stage.fetch_state_i\[6\]
+ sky130_fd_sc_hd__dfrtp_1
X_5139_ clknet_leaf_11_clk_i net358 net292 VGND VGND VPWR VPWR i_mem_slice_stage.mem_state_o\[46\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_79_485 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_94_433 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_94_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_54_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_352 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_62_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_54_16 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_85_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_57_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2840_ _0551_ _0753_ VGND VGND VPWR VPWR _0755_ sky130_fd_sc_hd__or2_1
XFILLER_0_72_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_5_405 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2771_ i_decode_stage.decode_state_o\[127\] _0631_ i_decode_stage.decode_state_o\[139\]
+ _0491_ _0347_ VGND VGND VPWR VPWR _0690_ sky130_fd_sc_hd__a221o_1
XFILLER_0_13_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4510_ _2182_ VGND VGND VPWR VPWR _0145_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_79_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4441_ _2042_ _2142_ VGND VGND VPWR VPWR _2143_ sky130_fd_sc_hd__or2_1
X_4372_ net205 _1927_ VGND VGND VPWR VPWR _2088_ sky130_fd_sc_hd__and2_1
XTAP_400 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3323_ _1148_ _1145_ _0891_ _1163_ VGND VGND VPWR VPWR _1227_ sky130_fd_sc_hd__a211o_1
XFILLER_0_0_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_411 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_422 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_433 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3254_ _0448_ _1041_ _1154_ _1159_ _0892_ VGND VGND VPWR VPWR _1160_ sky130_fd_sc_hd__o32a_1
XTAP_444 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_455 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_466 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_477 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_488 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_499 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3185_ _0691_ _0703_ _0344_ VGND VGND VPWR VPWR _1097_ sky130_fd_sc_hd__mux2_1
XFILLER_0_88_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_63_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_63_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2969_ _0677_ _0880_ VGND VGND VPWR VPWR _0881_ sky130_fd_sc_hd__xnor2_4
X_4708_ _2276_ VGND VGND VPWR VPWR _0249_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_32_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4639_ i_decode_stage.fetch_state_i\[9\] _2069_ _2234_ VGND VGND VPWR VPWR _2247_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_99_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_82_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_35_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_40_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_23_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_65_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4990_ clknet_leaf_0_clk_i _0170_ net281 VGND VGND VPWR VPWR i_decode_stage.reg_meta_o\[51\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_58_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3941_ _1110_ _0776_ _1798_ VGND VGND VPWR VPWR net183 sky130_fd_sc_hd__o21ai_1
X_3872_ _0709_ _1459_ _1749_ VGND VGND VPWR VPWR _1750_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_85_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_263 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_14_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2823_ _0736_ _0737_ VGND VGND VPWR VPWR _0738_ sky130_fd_sc_hd__or2_2
XFILLER_0_45_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2754_ i_mem_slice_stage.mem_state_o\[77\] _0328_ _0674_ _0330_ VGND VGND VPWR VPWR
+ net270 sky130_fd_sc_hd__a22o_1
XFILLER_0_26_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2685_ i_mem_slice_stage.mem_state_o\[86\] _0328_ _0612_ _0330_ VGND VGND VPWR VPWR
+ net248 sky130_fd_sc_hd__a22o_1
XFILLER_0_1_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4424_ net217 _1929_ _2128_ VGND VGND VPWR VPWR _0113_ sky130_fd_sc_hd__a21o_1
X_4355_ net132 _2047_ _2048_ _2073_ _2074_ VGND VGND VPWR VPWR _0098_ sky130_fd_sc_hd__o221a_1
XFILLER_0_1_485 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3306_ _0417_ _0883_ _0884_ _0413_ _0424_ VGND VGND VPWR VPWR _1210_ sky130_fd_sc_hd__o221a_1
XTAP_230 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_241 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_274 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_263 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_252 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4286_ _2025_ VGND VGND VPWR VPWR _0078_ sky130_fd_sc_hd__clkbuf_1
X_3237_ _1128_ _1132_ _1142_ _1129_ VGND VGND VPWR VPWR _1143_ sky130_fd_sc_hd__a22o_1
XTAP_296 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_285 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3168_ _0343_ _0945_ VGND VGND VPWR VPWR _1080_ sky130_fd_sc_hd__nor2_1
XFILLER_0_68_219 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3099_ _1009_ _1010_ VGND VGND VPWR VPWR _1011_ sky130_fd_sc_hd__nand2_1
XFILLER_0_91_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_32_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_82_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_51_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_27_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_366 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_35_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2470_ _0394_ _0404_ VGND VGND VPWR VPWR _0420_ sky130_fd_sc_hd__or2_1
XFILLER_0_23_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4140_ i_decode_stage.fetch_state_i\[6\] i_decode_stage.decode_state_o\[14\] _1936_
+ VGND VGND VPWR VPWR _1948_ sky130_fd_sc_hd__mux2_1
X_4071_ _1841_ _1888_ _1842_ VGND VGND VPWR VPWR _1889_ sky130_fd_sc_hd__o21bai_1
X_3022_ _2333_ _0932_ _0933_ VGND VGND VPWR VPWR _0934_ sky130_fd_sc_hd__a21oi_4
XFILLER_0_93_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4973_ clknet_leaf_10_clk_i _0153_ net292 VGND VGND VPWR VPWR i_decode_stage.reg_meta_o\[34\]
+ sky130_fd_sc_hd__dfrtp_1
X_3924_ net178 _1788_ _0601_ VGND VGND VPWR VPWR _1789_ sky130_fd_sc_hd__mux2_1
XFILLER_0_73_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3855_ _1662_ _1733_ _0660_ VGND VGND VPWR VPWR _1734_ sky130_fd_sc_hd__mux2_1
XFILLER_0_61_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3786_ _1198_ _0771_ _1666_ _1668_ VGND VGND VPWR VPWR _1669_ sky130_fd_sc_hd__a211o_1
X_2806_ _0723_ VGND VGND VPWR VPWR net199 sky130_fd_sc_hd__dlymetal6s2s_1
X_2737_ _0523_ VGND VGND VPWR VPWR _0660_ sky130_fd_sc_hd__buf_8
XFILLER_0_14_333 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2668_ _0363_ _0369_ _0374_ net246 VGND VGND VPWR VPWR _0597_ sky130_fd_sc_hd__and4_1
X_4407_ net144 _1924_ _2042_ _2114_ VGND VGND VPWR VPWR _2115_ sky130_fd_sc_hd__o22a_1
X_2599_ _0346_ i_decode_stage.decode_state_o\[134\] VGND VGND VPWR VPWR _0536_ sky130_fd_sc_hd__or2b_1
X_4338_ net228 _1840_ VGND VGND VPWR VPWR _2062_ sky130_fd_sc_hd__or2_1
XFILLER_0_5_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_5_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4269_ i_decode_stage.decode_state_o\[131\] net53 _2012_ VGND VGND VPWR VPWR _2014_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_96_314 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_84_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_393 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_32_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_28_458 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_70_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_3_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3640_ _0996_ _1529_ _0991_ VGND VGND VPWR VPWR _1530_ sky130_fd_sc_hd__o21a_1
X_3571_ _0858_ _0940_ _1429_ VGND VGND VPWR VPWR _1465_ sky130_fd_sc_hd__or3_1
XFILLER_0_23_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_23_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_51_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2522_ i_exec_stage.data_fwd_o\[25\] _0467_ _0460_ VGND VGND VPWR VPWR _0468_ sky130_fd_sc_hd__mux2_1
XFILLER_0_11_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5241_ clknet_leaf_29_clk_i _0240_ net291 VGND VGND VPWR VPWR i_decode_stage.fetch_state_i\[39\]
+ sky130_fd_sc_hd__dfrtp_1
X_2453_ i_decode_stage.decode_state_o\[125\] i_decode_stage.decode_state_o\[137\]
+ i_decode_stage.decode_state_o\[234\] VGND VGND VPWR VPWR _0403_ sky130_fd_sc_hd__mux2_1
X_5172_ clknet_leaf_42_clk_i net342 net280 VGND VGND VPWR VPWR i_mem_slice_stage.mem_state_o\[79\]
+ sky130_fd_sc_hd__dfrtp_1
X_2384_ i_decode_stage.decode_state_o\[233\] VGND VGND VPWR VPWR _0337_ sky130_fd_sc_hd__inv_2
X_4123_ net60 net61 net62 VGND VGND VPWR VPWR _1938_ sky130_fd_sc_hd__and3b_1
Xinput2 dmem_rdata_i[10] VGND VGND VPWR VPWR net2 sky130_fd_sc_hd__clkbuf_1
X_4054_ _0615_ _1785_ _0855_ _0606_ VGND VGND VPWR VPWR _1872_ sky130_fd_sc_hd__a22o_1
X_3005_ _0726_ _0914_ _0915_ _0916_ VGND VGND VPWR VPWR _0917_ sky130_fd_sc_hd__a31oi_4
XFILLER_0_36_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_414 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4956_ clknet_leaf_3_clk_i _0136_ net283 VGND VGND VPWR VPWR i_decode_stage.reg_meta_o\[17\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_46_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3907_ _0386_ _0922_ _0923_ _0924_ VGND VGND VPWR VPWR _1778_ sky130_fd_sc_hd__o31a_1
X_4887_ clknet_leaf_19_clk_i _0067_ net296 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[71\]
+ sky130_fd_sc_hd__dfrtp_1
X_3838_ _0345_ _0556_ _1067_ VGND VGND VPWR VPWR _1718_ sky130_fd_sc_hd__a21o_1
XFILLER_0_61_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_6_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3769_ _1640_ _1641_ _1649_ _1652_ VGND VGND VPWR VPWR _1653_ sky130_fd_sc_hd__o211a_1
XFILLER_0_69_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_1012 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1001 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1056 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1045 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1034 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1023 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_1089 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1078 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1067 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_211 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_80_501 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_25_417 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_807 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_818 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_829 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_73_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_87_144 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4810_ _2327_ VGND VGND VPWR VPWR _0300_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_68_391 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_90_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4741_ i_exec_stage.data_fwd_o\[1\] i_exec_stage.alu_out\[0\] _1839_ VGND VGND VPWR
+ VPWR _2293_ sky130_fd_sc_hd__mux2_1
XFILLER_0_22_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4672_ i_decode_stage.fetch_state_i\[29\] _1929_ _2147_ VGND VGND VPWR VPWR _0230_
+ sky130_fd_sc_hd__a21o_1
XFILLER_0_43_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3623_ _1198_ _0964_ VGND VGND VPWR VPWR _1514_ sky130_fd_sc_hd__nand2_1
X_3554_ _0608_ _0857_ VGND VGND VPWR VPWR _1448_ sky130_fd_sc_hd__nor2_1
X_2505_ i_mem_slice_stage.mem_state_o\[36\] VGND VGND VPWR VPWR _0453_ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_11_155 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_11_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3485_ _1377_ _1378_ _1381_ _1382_ VGND VGND VPWR VPWR _1383_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_0_11_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5224_ clknet_leaf_24_clk_i _0223_ net290 VGND VGND VPWR VPWR i_decode_stage.fetch_state_i\[22\]
+ sky130_fd_sc_hd__dfrtp_1
X_2436_ i_mem_slice_stage.mem_state_o\[72\] _0328_ _0387_ _0330_ VGND VGND VPWR VPWR
+ net253 sky130_fd_sc_hd__a22o_2
X_5155_ clknet_leaf_15_clk_i net393 net293 VGND VGND VPWR VPWR i_mem_slice_stage.mem_state_o\[62\]
+ sky130_fd_sc_hd__dfrtp_1
X_2367_ _0311_ _0316_ _0320_ VGND VGND VPWR VPWR _0321_ sky130_fd_sc_hd__or3_1
X_5086_ clknet_leaf_24_clk_i i_decode_stage.decode_state_o\[30\] net289 VGND VGND
+ VPWR VPWR i_exec_stage.exec_state_o\[61\] sky130_fd_sc_hd__dfrtp_1
X_4106_ i_decode_stage.valid_o _1923_ VGND VGND VPWR VPWR _1924_ sky130_fd_sc_hd__nand2_8
X_4037_ _0336_ _0381_ _0391_ _0402_ VGND VGND VPWR VPWR _1855_ sky130_fd_sc_hd__o22ai_1
XPHY_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_66_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_66_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_93_125 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_93_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4939_ clknet_leaf_25_clk_i _0119_ net290 VGND VGND VPWR VPWR net224 sky130_fd_sc_hd__dfrtp_2
XANTENNA_40 net155 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_73 net133 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_51 net222 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_62 _0626_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_84 net156 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_15_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_6_182 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_30_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_100_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput191 net191 VGND VGND VPWR VPWR dmem_wdata_o[31] sky130_fd_sc_hd__buf_2
Xoutput180 net180 VGND VGND VPWR VPWR dmem_wdata_o[21] sky130_fd_sc_hd__buf_2
XFILLER_0_43_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_97_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_57_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_25_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_25_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_65_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_25_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3270_ _0422_ _0696_ _0662_ VGND VGND VPWR VPWR _1175_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_21_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_604 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_615 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_626 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_637 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_648 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_659 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_453 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_75_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_33_95 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_90_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4724_ _2284_ VGND VGND VPWR VPWR _0257_ sky130_fd_sc_hd__clkbuf_1
X_2985_ _0869_ _0882_ _0886_ _0896_ VGND VGND VPWR VPWR _0897_ sky130_fd_sc_hd__or4_2
XFILLER_0_16_236 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_56_394 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4655_ i_decode_stage.fetch_state_i\[17\] _2097_ _2234_ VGND VGND VPWR VPWR _2255_
+ sky130_fd_sc_hd__mux2_1
X_3606_ _1414_ _1497_ _0660_ VGND VGND VPWR VPWR _1498_ sky130_fd_sc_hd__mux2_1
Xinput60 imem_rdata_i[4] VGND VGND VPWR VPWR net60 sky130_fd_sc_hd__buf_2
Xinput71 rf_rs1_i[13] VGND VGND VPWR VPWR net71 sky130_fd_sc_hd__clkbuf_1
X_4586_ i_decode_stage.reg_meta_o\[64\] net79 _2207_ VGND VGND VPWR VPWR _2221_ sky130_fd_sc_hd__mux2_1
Xinput82 rf_rs1_i[23] VGND VGND VPWR VPWR net82 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_71_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3537_ _0344_ _0603_ _0641_ VGND VGND VPWR VPWR _1432_ sky130_fd_sc_hd__a21o_1
XFILLER_0_3_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput93 rf_rs1_i[4] VGND VGND VPWR VPWR net93 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_12_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3468_ _1340_ _1364_ _1365_ VGND VGND VPWR VPWR _1366_ sky130_fd_sc_hd__a21o_1
X_3399_ _1169_ _1181_ _0525_ VGND VGND VPWR VPWR _1300_ sky130_fd_sc_hd__mux2_1
X_2419_ i_decode_stage.decode_state_o\[122\] net278 VGND VGND VPWR VPWR _0371_ sky130_fd_sc_hd__or2b_1
X_5207_ clknet_leaf_40_clk_i _0206_ net281 VGND VGND VPWR VPWR i_decode_stage.fetch_state_i\[5\]
+ sky130_fd_sc_hd__dfrtp_1
X_5138_ clknet_leaf_10_clk_i net383 net292 VGND VGND VPWR VPWR i_mem_slice_stage.mem_state_o\[45\]
+ sky130_fd_sc_hd__dfrtp_1
X_5069_ clknet_leaf_42_clk_i i_decode_stage.decode_state_o\[13\] net280 VGND VGND
+ VPWR VPWR i_exec_stage.exec_state_o\[44\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_94_445 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_79_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_66_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_66_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_94_489 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_81_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_74_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_leaf_15_clk_i clknet_2_2__leaf_clk_i VGND VGND VPWR VPWR clknet_leaf_15_clk_i
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_30_294 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_38_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_89_206 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_85_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_57_169 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_26_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_417 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2770_ _0358_ _0686_ _0687_ _0688_ VGND VGND VPWR VPWR _0689_ sky130_fd_sc_hd__o31a_2
XFILLER_0_80_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4440_ _2140_ _0722_ _2141_ VGND VGND VPWR VPWR _2142_ sky130_fd_sc_hd__and3b_1
X_4371_ _2085_ _2086_ VGND VGND VPWR VPWR _2087_ sky130_fd_sc_hd__nor2_1
XFILLER_0_95_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3322_ _0884_ _0885_ VGND VGND VPWR VPWR _1226_ sky130_fd_sc_hd__or2_1
XTAP_401 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_412 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_423 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3253_ _1156_ _0889_ _1145_ _1158_ VGND VGND VPWR VPWR _1159_ sky130_fd_sc_hd__o2bb2a_1
XTAP_434 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_445 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_456 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_467 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3184_ _0345_ _0404_ _1042_ _0421_ VGND VGND VPWR VPWR _1096_ sky130_fd_sc_hd__o211a_1
XTAP_478 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_489 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_76_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_88_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2968_ _2333_ net195 _0879_ VGND VGND VPWR VPWR _0880_ sky130_fd_sc_hd__a21oi_4
X_4707_ net207 i_decode_stage.fetch_state_i\[48\] _1927_ VGND VGND VPWR VPWR _2276_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_44_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4638_ _2246_ VGND VGND VPWR VPWR _0209_ sky130_fd_sc_hd__clkbuf_1
X_2899_ _2333_ _0812_ _0813_ VGND VGND VPWR VPWR _0814_ sky130_fd_sc_hd__a21o_1
X_4569_ _2212_ VGND VGND VPWR VPWR _0174_ sky130_fd_sc_hd__clkbuf_1
XTAP_990 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_250 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_94_253 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_94_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_39_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_54_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3940_ _0336_ _1774_ _1112_ _0908_ VGND VGND VPWR VPWR _1798_ sky130_fd_sc_hd__o22a_1
X_3871_ _0709_ _0712_ _1326_ _1604_ _1748_ VGND VGND VPWR VPWR _1749_ sky130_fd_sc_hd__o221a_1
XFILLER_0_85_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_14_64 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2822_ _0532_ _0735_ VGND VGND VPWR VPWR _0737_ sky130_fd_sc_hd__and2_1
X_2753_ i_mem_slice_stage.mem_state_o\[45\] i_mem_slice_stage.mem_state_o\[6\] _0453_
+ VGND VGND VPWR VPWR _0674_ sky130_fd_sc_hd__mux2_1
XFILLER_0_26_386 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2684_ i_mem_slice_stage.mem_state_o\[54\] i_mem_slice_stage.mem_state_o\[15\] _0453_
+ VGND VGND VPWR VPWR _0612_ sky130_fd_sc_hd__mux2_2
X_4423_ net147 _1924_ _2042_ _2127_ VGND VGND VPWR VPWR _2128_ sky130_fd_sc_hd__o22a_1
X_4354_ net201 _1840_ VGND VGND VPWR VPWR _2074_ sky130_fd_sc_hd__or2_1
X_3305_ _1198_ _0884_ VGND VGND VPWR VPWR _1209_ sky130_fd_sc_hd__nand2_1
XTAP_220 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_1_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_231 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_242 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_275 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_264 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_253 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4285_ i_decode_stage.decode_state_o\[232\] _2024_ _2012_ VGND VGND VPWR VPWR _2025_
+ sky130_fd_sc_hd__mux2_1
X_3236_ _1137_ _1141_ _0590_ VGND VGND VPWR VPWR _1142_ sky130_fd_sc_hd__mux2_1
XTAP_297 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_286 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3167_ _1076_ _1078_ _0421_ VGND VGND VPWR VPWR _1079_ sky130_fd_sc_hd__mux2_1
X_3098_ _0568_ _0761_ VGND VGND VPWR VPWR _1010_ sky130_fd_sc_hd__and2b_1
XFILLER_0_64_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_36_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_72_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_99_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_67_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_297 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_82_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_76_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4070_ _1848_ _1887_ _1850_ VGND VGND VPWR VPWR _1888_ sky130_fd_sc_hd__o21a_1
X_3021_ i_decode_stage.decode_state_o\[50\] _0339_ _0751_ i_decode_stage.decode_state_o\[134\]
+ VGND VGND VPWR VPWR _0933_ sky130_fd_sc_hd__a22o_1
X_4972_ clknet_leaf_10_clk_i _0152_ net292 VGND VGND VPWR VPWR i_decode_stage.reg_meta_o\[33\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_58_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3923_ _0961_ VGND VGND VPWR VPWR _1788_ sky130_fd_sc_hd__inv_2
X_3854_ _1698_ _1732_ _0422_ VGND VGND VPWR VPWR _1733_ sky130_fd_sc_hd__mux2_1
XFILLER_0_18_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_73_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2805_ i_decode_stage.valid_o i_decode_stage.decode_state_o\[3\] _0722_ VGND VGND
+ VPWR VPWR _0723_ sky130_fd_sc_hd__and3_1
XFILLER_0_26_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3785_ _1199_ _0772_ _1657_ _1144_ _1667_ VGND VGND VPWR VPWR _1668_ sky130_fd_sc_hd__a221o_1
X_2736_ _0642_ _0658_ _0422_ VGND VGND VPWR VPWR _0659_ sky130_fd_sc_hd__mux2_1
XFILLER_0_14_345 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2667_ i_mem_slice_stage.mem_state_o\[84\] _0328_ _0596_ _0330_ VGND VGND VPWR VPWR
+ net246 sky130_fd_sc_hd__a22o_1
XFILLER_0_41_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4406_ _2112_ _0722_ _2113_ VGND VGND VPWR VPWR _2114_ sky130_fd_sc_hd__and3b_1
XFILLER_0_67_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2598_ i_exec_stage.data_fwd_o\[31\] _0534_ _0460_ VGND VGND VPWR VPWR _0535_ sky130_fd_sc_hd__mux2_1
X_4337_ _2059_ _2060_ VGND VGND VPWR VPWR _2061_ sky130_fd_sc_hd__and2_1
XFILLER_0_5_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4268_ _2013_ VGND VGND VPWR VPWR _0072_ sky130_fd_sc_hd__clkbuf_1
X_3219_ _1122_ _1124_ _0525_ VGND VGND VPWR VPWR _1125_ sky130_fd_sc_hd__mux2_1
X_4199_ i_decode_stage.decode_state_o\[43\] i_decode_stage.fetch_state_i\[35\] _1840_
+ VGND VGND VPWR VPWR _1978_ sky130_fd_sc_hd__mux2_1
XFILLER_0_96_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_60_451 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_32_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_95_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_55_267 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_11_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3570_ _0940_ _1429_ _0858_ VGND VGND VPWR VPWR _1464_ sky130_fd_sc_hd__o21a_1
XFILLER_0_11_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2521_ net258 i_decode_stage.reg_meta_o\[68\] _0457_ VGND VGND VPWR VPWR _0467_ sky130_fd_sc_hd__mux2_1
X_5240_ clknet_leaf_39_clk_i _0239_ net282 VGND VGND VPWR VPWR i_decode_stage.fetch_state_i\[38\]
+ sky130_fd_sc_hd__dfrtp_1
X_2452_ _0358_ _0395_ _0399_ _0401_ VGND VGND VPWR VPWR _0402_ sky130_fd_sc_hd__o31ai_4
X_5171_ clknet_leaf_42_clk_i net391 net281 VGND VGND VPWR VPWR i_mem_slice_stage.mem_state_o\[78\]
+ sky130_fd_sc_hd__dfrtp_1
X_2383_ _0306_ _0322_ _0331_ _0335_ VGND VGND VPWR VPWR _0336_ sky130_fd_sc_hd__a31oi_4
X_4122_ net56 net34 net45 VGND VGND VPWR VPWR _1937_ sky130_fd_sc_hd__and3_1
X_4053_ _0649_ _1868_ _1869_ _0655_ _1870_ VGND VGND VPWR VPWR _1871_ sky130_fd_sc_hd__o221ai_2
Xinput3 dmem_rdata_i[11] VGND VGND VPWR VPWR net3 sky130_fd_sc_hd__clkbuf_1
X_3004_ _0647_ _0332_ _0333_ _0334_ VGND VGND VPWR VPWR _0916_ sky130_fd_sc_hd__and4_1
XFILLER_0_36_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4955_ clknet_leaf_3_clk_i _0135_ net283 VGND VGND VPWR VPWR i_decode_stage.reg_meta_o\[16\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_86_381 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_19_426 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3906_ _0932_ _1774_ _1777_ VGND VGND VPWR VPWR net168 sky130_fd_sc_hd__a21o_1
X_4886_ clknet_leaf_19_clk_i _0066_ net296 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[70\]
+ sky130_fd_sc_hd__dfrtp_1
X_3837_ _0422_ _1679_ VGND VGND VPWR VPWR _1717_ sky130_fd_sc_hd__or2_1
X_3768_ _0424_ _1651_ _0780_ VGND VGND VPWR VPWR _1652_ sky130_fd_sc_hd__a21o_1
X_2719_ _0363_ _0369_ _0374_ i_decode_stage.reg_meta_o\[53\] VGND VGND VPWR VPWR _0643_
+ sky130_fd_sc_hd__a31oi_2
XFILLER_0_100_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3699_ _0345_ _0478_ _0501_ VGND VGND VPWR VPWR _1586_ sky130_fd_sc_hd__a21o_1
XFILLER_0_14_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_1013 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1002 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1046 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1035 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1024 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1079 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1068 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1057 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_25_429 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_33_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_808 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_819 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_7_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4740_ _2292_ VGND VGND VPWR VPWR _0265_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_16_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4671_ i_decode_stage.fetch_state_i\[28\] _1929_ _2142_ VGND VGND VPWR VPWR _0229_
+ sky130_fd_sc_hd__a21o_1
XFILLER_0_71_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3622_ _1129_ _0583_ _1479_ VGND VGND VPWR VPWR _1513_ sky130_fd_sc_hd__a21o_1
XFILLER_0_43_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_309 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3553_ _0858_ _1446_ VGND VGND VPWR VPWR _1447_ sky130_fd_sc_hd__xnor2_1
X_2504_ _0328_ VGND VGND VPWR VPWR _0452_ sky130_fd_sc_hd__buf_4
X_3484_ _0656_ _0934_ VGND VGND VPWR VPWR _1382_ sky130_fd_sc_hd__nand2_1
X_2435_ i_mem_slice_stage.mem_state_o\[40\] i_mem_slice_stage.mem_state_o\[1\] i_mem_slice_stage.mem_state_o\[36\]
+ VGND VGND VPWR VPWR _0387_ sky130_fd_sc_hd__mux2_1
XFILLER_0_11_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5223_ clknet_leaf_32_clk_i _0222_ net287 VGND VGND VPWR VPWR i_decode_stage.fetch_state_i\[21\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_51_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5154_ clknet_leaf_16_clk_i net360 net295 VGND VGND VPWR VPWR i_mem_slice_stage.mem_state_o\[61\]
+ sky130_fd_sc_hd__dfrtp_1
X_2366_ i_decode_stage.reg_meta_o\[43\] _0317_ _0318_ _0319_ VGND VGND VPWR VPWR _0320_
+ sky130_fd_sc_hd__nand4_2
X_4105_ i_decode_stage.decode_state_o\[242\] _1913_ _1914_ _1922_ i_decode_stage.decode_state_o\[243\]
+ VGND VGND VPWR VPWR _1923_ sky130_fd_sc_hd__a221o_2
X_5085_ clknet_leaf_23_clk_i i_decode_stage.decode_state_o\[29\] net288 VGND VGND
+ VPWR VPWR i_exec_stage.exec_state_o\[60\] sky130_fd_sc_hd__dfrtp_1
X_4036_ _0391_ _0402_ VGND VGND VPWR VPWR _1854_ sky130_fd_sc_hd__nand2_1
XFILLER_0_78_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_63_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_63_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_93_137 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4938_ clknet_leaf_25_clk_i _0118_ net289 VGND VGND VPWR VPWR net223 sky130_fd_sc_hd__dfrtp_2
XFILLER_0_74_384 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4869_ clknet_leaf_29_clk_i _0049_ net285 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[53\]
+ sky130_fd_sc_hd__dfrtp_1
XANTENNA_41 net155 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_30 net135 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_52 net226 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_74 net133 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_63 _1666_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_15_473 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_6_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_85 net166 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xoutput170 net170 VGND VGND VPWR VPWR dmem_wdata_o[12] sky130_fd_sc_hd__buf_2
XFILLER_0_30_498 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xoutput181 net181 VGND VGND VPWR VPWR dmem_wdata_o[22] sky130_fd_sc_hd__clkbuf_4
Xoutput192 net192 VGND VGND VPWR VPWR dmem_wdata_o[3] sky130_fd_sc_hd__clkbuf_4
XPHY_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_337 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_605 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_616 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_627 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_638 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_649 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_88_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2984_ _0887_ _0889_ _0892_ _0894_ _0895_ VGND VGND VPWR VPWR _0896_ sky130_fd_sc_hd__o311a_1
X_4723_ net216 i_decode_stage.fetch_state_i\[56\] _1927_ VGND VGND VPWR VPWR _2284_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_71_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4654_ _2254_ VGND VGND VPWR VPWR _0217_ sky130_fd_sc_hd__clkbuf_1
X_3605_ _1456_ _1496_ _0422_ VGND VGND VPWR VPWR _1497_ sky130_fd_sc_hd__mux2_1
Xinput50 imem_rdata_i[24] VGND VGND VPWR VPWR net50 sky130_fd_sc_hd__clkbuf_4
Xinput61 imem_rdata_i[5] VGND VGND VPWR VPWR net61 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_12_421 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4585_ _2220_ VGND VGND VPWR VPWR _0182_ sky130_fd_sc_hd__clkbuf_1
Xinput72 rf_rs1_i[14] VGND VGND VPWR VPWR net72 sky130_fd_sc_hd__clkbuf_1
Xinput94 rf_rs1_i[5] VGND VGND VPWR VPWR net94 sky130_fd_sc_hd__clkbuf_1
Xinput83 rf_rs1_i[24] VGND VGND VPWR VPWR net83 sky130_fd_sc_hd__clkbuf_1
X_3536_ _0843_ _0939_ _1405_ _1430_ VGND VGND VPWR VPWR _1431_ sky130_fd_sc_hd__o31a_1
XFILLER_0_3_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5206_ clknet_leaf_42_clk_i _0205_ net282 VGND VGND VPWR VPWR i_decode_stage.fetch_state_i\[4\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_58_71 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3467_ _0911_ _1355_ _1351_ VGND VGND VPWR VPWR _1365_ sky130_fd_sc_hd__a21o_1
X_3398_ _1281_ _1298_ VGND VGND VPWR VPWR _1299_ sky130_fd_sc_hd__and2_1
X_2418_ _0370_ VGND VGND VPWR VPWR net274 sky130_fd_sc_hd__buf_2
X_2349_ i_decode_stage.decode_state_o\[125\] net276 VGND VGND VPWR VPWR _2339_ sky130_fd_sc_hd__xor2_2
X_5137_ clknet_leaf_11_clk_i net365 net292 VGND VGND VPWR VPWR i_mem_slice_stage.mem_state_o\[44\]
+ sky130_fd_sc_hd__dfrtp_1
X_5068_ clknet_leaf_42_clk_i i_decode_stage.decode_state_o\[12\] net280 VGND VGND
+ VPWR VPWR i_exec_stage.exec_state_o\[43\] sky130_fd_sc_hd__dfrtp_1
X_4019_ net25 _1829_ _1837_ VGND VGND VPWR VPWR i_mem_slice_stage.pre_data\[31\] sky130_fd_sc_hd__a21o_1
XFILLER_0_79_432 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_39_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_94_457 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_62_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_281 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_30_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_100_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_89_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_54_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_97_284 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_38_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_72_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_5_429 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_41_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4370_ net205 _2081_ VGND VGND VPWR VPWR _2086_ sky130_fd_sc_hd__nor2_1
X_3321_ _1129_ _1216_ _1217_ _1224_ _1074_ VGND VGND VPWR VPWR _1225_ sky130_fd_sc_hd__o311a_1
XTAP_402 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_413 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_424 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3252_ _1157_ VGND VGND VPWR VPWR _1158_ sky130_fd_sc_hd__buf_4
XTAP_435 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_446 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_457 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3183_ _1090_ _1094_ _0421_ VGND VGND VPWR VPWR _1095_ sky130_fd_sc_hd__mux2_1
XTAP_468 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_479 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_223 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_91_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_44_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_56_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2967_ i_decode_stage.decode_state_o\[46\] _0339_ _0751_ i_decode_stage.decode_state_o\[130\]
+ VGND VGND VPWR VPWR _0879_ sky130_fd_sc_hd__a22o_1
XFILLER_0_97_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4706_ _2275_ VGND VGND VPWR VPWR _0248_ sky130_fd_sc_hd__clkbuf_1
X_2898_ i_decode_stage.decode_state_o\[60\] _0731_ _0733_ VGND VGND VPWR VPWR _0813_
+ sky130_fd_sc_hd__a21oi_1
X_4637_ i_decode_stage.fetch_state_i\[8\] _2067_ _2234_ VGND VGND VPWR VPWR _2246_
+ sky130_fd_sc_hd__mux2_1
X_4568_ i_decode_stage.reg_meta_o\[55\] net69 _2207_ VGND VGND VPWR VPWR _2212_ sky130_fd_sc_hd__mux2_1
XFILLER_0_12_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3519_ _1328_ _1414_ _0523_ VGND VGND VPWR VPWR _1415_ sky130_fd_sc_hd__mux2_1
X_4499_ _2176_ VGND VGND VPWR VPWR _0140_ sky130_fd_sc_hd__clkbuf_1
XTAP_980 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_991 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_94_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_23_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_85_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_58_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3870_ _0525_ _1681_ _1747_ _1041_ VGND VGND VPWR VPWR _1748_ sky130_fd_sc_hd__a211o_1
XFILLER_0_14_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2821_ _0532_ _0735_ VGND VGND VPWR VPWR _0736_ sky130_fd_sc_hd__nor2_1
XFILLER_0_14_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_26_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_73_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2752_ _0666_ _0672_ _0465_ VGND VGND VPWR VPWR _0673_ sky130_fd_sc_hd__mux2_1
XFILLER_0_5_248 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_26_398 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2683_ _0376_ _0377_ _0378_ i_decode_stage.reg_meta_o\[59\] VGND VGND VPWR VPWR _0611_
+ sky130_fd_sc_hd__o31a_1
X_4422_ _2125_ _0722_ _2126_ VGND VGND VPWR VPWR _2127_ sky130_fd_sc_hd__and3b_1
XFILLER_0_41_379 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4353_ _2071_ _2072_ VGND VGND VPWR VPWR _2073_ sky130_fd_sc_hd__nor2_1
X_3304_ _1043_ _1207_ _0523_ VGND VGND VPWR VPWR _1208_ sky130_fd_sc_hd__mux2_2
XTAP_210 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_221 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_232 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4284_ net59 _1939_ _2023_ _1934_ VGND VGND VPWR VPWR _2024_ sky130_fd_sc_hd__o211ai_1
X_3235_ _0660_ _1138_ _1140_ VGND VGND VPWR VPWR _1141_ sky130_fd_sc_hd__o21a_1
XTAP_265 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_243 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_254 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_298 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_287 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_276 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3166_ _0345_ _0640_ _1077_ VGND VGND VPWR VPWR _1078_ sky130_fd_sc_hd__a21oi_1
Xclkbuf_leaf_14_clk_i clknet_2_2__leaf_clk_i VGND VGND VPWR VPWR clknet_leaf_14_clk_i
+ sky130_fd_sc_hd__clkbuf_16
X_3097_ _0754_ _0755_ VGND VGND VPWR VPWR _1009_ sky130_fd_sc_hd__nand2_1
XFILLER_0_12_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_49_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_76_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3999_ net6 _1807_ _1813_ _1827_ _1834_ VGND VGND VPWR VPWR i_mem_slice_stage.pre_data\[14\]
+ sky130_fd_sc_hd__a221o_1
XFILLER_0_76_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_leaf_29_clk_i clknet_2_1__leaf_clk_i VGND VGND VPWR VPWR clknet_leaf_29_clk_i
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_29_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_91_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_17_354 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_44_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_23_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_50_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_92_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_92_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3020_ _0386_ _0929_ _0930_ _0931_ VGND VGND VPWR VPWR _0932_ sky130_fd_sc_hd__o31a_2
X_4971_ clknet_leaf_10_clk_i _0151_ net292 VGND VGND VPWR VPWR i_decode_stage.reg_meta_o\[32\]
+ sky130_fd_sc_hd__dfrtp_1
X_3922_ _1787_ VGND VGND VPWR VPWR net174 sky130_fd_sc_hd__inv_2
X_3853_ _0345_ _0532_ _0557_ VGND VGND VPWR VPWR _1732_ sky130_fd_sc_hd__a21o_1
XFILLER_0_39_490 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2804_ _0721_ VGND VGND VPWR VPWR _0722_ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_73_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3784_ _0417_ _0563_ VGND VGND VPWR VPWR _1667_ sky130_fd_sc_hd__nor2_1
XFILLER_0_73_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2735_ _0345_ _0650_ _0657_ VGND VGND VPWR VPWR _0658_ sky130_fd_sc_hd__a21o_1
XFILLER_0_81_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_41_176 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2666_ i_mem_slice_stage.mem_state_o\[52\] i_mem_slice_stage.mem_state_o\[13\] _0453_
+ VGND VGND VPWR VPWR _0596_ sky130_fd_sc_hd__mux2_2
X_4405_ net212 net213 _2101_ net214 VGND VGND VPWR VPWR _2113_ sky130_fd_sc_hd__a31o_1
X_4336_ net228 _2055_ VGND VGND VPWR VPWR _2060_ sky130_fd_sc_hd__or2_1
X_2597_ net265 i_decode_stage.reg_meta_o\[74\] _0457_ VGND VGND VPWR VPWR _0534_ sky130_fd_sc_hd__mux2_1
X_4267_ i_decode_stage.decode_state_o\[130\] net52 _2012_ VGND VGND VPWR VPWR _2013_
+ sky130_fd_sc_hd__mux2_1
X_3218_ _1123_ VGND VGND VPWR VPWR _1124_ sky130_fd_sc_hd__clkinv_2
X_4198_ _1977_ VGND VGND VPWR VPWR _0038_ sky130_fd_sc_hd__clkbuf_1
X_3149_ _0343_ _0537_ VGND VGND VPWR VPWR _1061_ sky130_fd_sc_hd__nand2_1
XFILLER_0_96_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_17_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_52_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_316 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_99_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_95_393 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_55_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2520_ i_mem_slice_stage.mem_state_o\[95\] _0452_ _0466_ _0455_ VGND VGND VPWR VPWR
+ net258 sky130_fd_sc_hd__a22o_1
X_2451_ _0400_ _0352_ _0355_ _0357_ VGND VGND VPWR VPWR _0401_ sky130_fd_sc_hd__or4_1
X_5170_ clknet_leaf_43_clk_i net366 net280 VGND VGND VPWR VPWR i_mem_slice_stage.mem_state_o\[77\]
+ sky130_fd_sc_hd__dfrtp_1
X_2382_ i_exec_stage.data_fwd_o\[1\] _0332_ _0333_ _0334_ VGND VGND VPWR VPWR _0335_
+ sky130_fd_sc_hd__and4_1
X_4121_ _1926_ VGND VGND VPWR VPWR _1936_ sky130_fd_sc_hd__buf_12
X_4052_ _0638_ _0829_ _0925_ _0630_ VGND VGND VPWR VPWR _1870_ sky130_fd_sc_hd__o22a_1
Xinput4 dmem_rdata_i[12] VGND VGND VPWR VPWR net4 sky130_fd_sc_hd__clkbuf_1
X_3003_ _0324_ _0326_ i_decode_stage.reg_meta_o\[15\] VGND VGND VPWR VPWR _0915_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_36_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_78_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4954_ clknet_leaf_5_clk_i _0134_ net284 VGND VGND VPWR VPWR i_decode_stage.reg_meta_o\[15\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_86_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_46_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3905_ _0519_ _1774_ VGND VGND VPWR VPWR _1777_ sky130_fd_sc_hd__nor2_1
X_4885_ clknet_leaf_20_clk_i _0065_ net296 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[69\]
+ sky130_fd_sc_hd__dfrtp_1
X_3836_ _1423_ VGND VGND VPWR VPWR _1716_ sky130_fd_sc_hd__inv_2
XFILLER_0_6_321 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_61_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_6_365 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_42_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3767_ _0417_ _0470_ _0779_ _0413_ _1650_ VGND VGND VPWR VPWR _1651_ sky130_fd_sc_hd__o221a_1
X_2718_ _0345_ _0633_ _0641_ VGND VGND VPWR VPWR _0642_ sky130_fd_sc_hd__a21o_1
XFILLER_0_42_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3698_ _0809_ _1584_ VGND VGND VPWR VPWR _1585_ sky130_fd_sc_hd__xnor2_1
X_2649_ _0338_ i_decode_stage.decode_state_o\[139\] i_decode_stage.decode_state_o\[43\]
+ _0339_ _2332_ VGND VGND VPWR VPWR _0579_ sky130_fd_sc_hd__a221o_1
X_4319_ net152 _2042_ _2043_ _2046_ VGND VGND VPWR VPWR _0090_ sky130_fd_sc_hd__a22o_1
X_5299_ clknet_leaf_37_clk_i _0298_ VGND VGND VPWR VPWR i_exec_stage.data_fwd_o\[33\]
+ sky130_fd_sc_hd__dfxtp_1
XTAP_1003 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1047 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1036 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1025 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1014 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1069 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1058 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_809 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_56_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4670_ i_decode_stage.fetch_state_i\[27\] _1929_ _2137_ VGND VGND VPWR VPWR _0228_
+ sky130_fd_sc_hd__a21o_1
XFILLER_0_24_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3621_ _0966_ _1511_ VGND VGND VPWR VPWR _1512_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_3_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3552_ _1409_ _1444_ _1445_ VGND VGND VPWR VPWR _1446_ sky130_fd_sc_hd__a21o_1
X_2503_ _0450_ VGND VGND VPWR VPWR _0451_ sky130_fd_sc_hd__buf_12
X_3483_ _1198_ _1379_ _1380_ VGND VGND VPWR VPWR _1381_ sky130_fd_sc_hd__a21bo_1
X_5222_ clknet_leaf_32_clk_i _0221_ net287 VGND VGND VPWR VPWR i_decode_stage.fetch_state_i\[20\]
+ sky130_fd_sc_hd__dfrtp_1
X_2434_ _0385_ VGND VGND VPWR VPWR _0386_ sky130_fd_sc_hd__clkbuf_16
X_5153_ clknet_leaf_15_clk_i net364 net293 VGND VGND VPWR VPWR i_mem_slice_stage.mem_state_o\[60\]
+ sky130_fd_sc_hd__dfrtp_1
X_2365_ i_exec_stage.data_fwd_o\[0\] i_exec_stage.data_fwd_o\[39\] VGND VGND VPWR
+ VPWR _0319_ sky130_fd_sc_hd__and2_1
XFILLER_0_44_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4104_ i_decode_stage.decode_state_o\[240\] _1921_ VGND VGND VPWR VPWR _1922_ sky130_fd_sc_hd__xnor2_1
X_5084_ clknet_leaf_32_clk_i i_decode_stage.decode_state_o\[28\] net287 VGND VGND
+ VPWR VPWR i_exec_stage.exec_state_o\[59\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_47_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4035_ _0578_ _0689_ _0701_ _0519_ VGND VGND VPWR VPWR _1853_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_47_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_93_149 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_74_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4937_ clknet_leaf_26_clk_i _0117_ net289 VGND VGND VPWR VPWR net221 sky130_fd_sc_hd__dfrtp_2
XFILLER_0_59_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4868_ clknet_leaf_29_clk_i _0048_ net285 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[52\]
+ sky130_fd_sc_hd__dfrtp_1
XANTENNA_20 net43 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_19_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_34_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_31 net135 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3819_ _0662_ _1626_ VGND VGND VPWR VPWR _1700_ sky130_fd_sc_hd__nand2_1
XFILLER_0_74_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_53 net228 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_42 net155 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_34_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_75 net134 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_64 _1702_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_86 net206 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4799_ i_exec_stage.data_fwd_o\[30\] net151 _1838_ VGND VGND VPWR VPWR _2322_ sky130_fd_sc_hd__mux2_1
XFILLER_0_15_485 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_100_321 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xoutput160 net160 VGND VGND VPWR VPWR dmem_addr_o[8] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_100_365 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xoutput182 net182 VGND VGND VPWR VPWR dmem_wdata_o[23] sky130_fd_sc_hd__clkbuf_4
Xoutput171 net171 VGND VGND VPWR VPWR dmem_wdata_o[13] sky130_fd_sc_hd__clkbuf_4
Xoutput193 net193 VGND VGND VPWR VPWR dmem_wdata_o[4] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_57_308 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_80_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_349 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_606 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_617 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_628 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_639 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_88_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_29_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2983_ _0589_ _0691_ VGND VGND VPWR VPWR _0895_ sky130_fd_sc_hd__nand2_1
XFILLER_0_33_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4722_ _2283_ VGND VGND VPWR VPWR _0256_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_56_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_71_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_83_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xinput40 imem_rdata_i[15] VGND VGND VPWR VPWR net40 sky130_fd_sc_hd__clkbuf_4
X_4653_ i_decode_stage.fetch_state_i\[16\] _2093_ _2234_ VGND VGND VPWR VPWR _2254_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_71_377 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3604_ _0345_ _0622_ _1075_ VGND VGND VPWR VPWR _1496_ sky130_fd_sc_hd__a21oi_1
Xinput51 imem_rdata_i[25] VGND VGND VPWR VPWR net51 sky130_fd_sc_hd__clkbuf_1
Xinput62 imem_rdata_i[6] VGND VGND VPWR VPWR net62 sky130_fd_sc_hd__clkbuf_2
Xinput73 rf_rs1_i[15] VGND VGND VPWR VPWR net73 sky130_fd_sc_hd__clkbuf_1
X_4584_ i_decode_stage.reg_meta_o\[63\] net77 _2207_ VGND VGND VPWR VPWR _2220_ sky130_fd_sc_hd__mux2_1
XFILLER_0_12_433 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xinput95 rf_rs1_i[6] VGND VGND VPWR VPWR net95 sky130_fd_sc_hd__clkbuf_1
Xinput84 rf_rs1_i[25] VGND VGND VPWR VPWR net84 sky130_fd_sc_hd__clkbuf_1
X_3535_ _0430_ _1429_ VGND VGND VPWR VPWR _1430_ sky130_fd_sc_hd__nor2_1
XFILLER_0_12_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3466_ _0913_ _0921_ VGND VGND VPWR VPWR _1364_ sky130_fd_sc_hd__and2_1
X_5205_ clknet_leaf_40_clk_i _0204_ net282 VGND VGND VPWR VPWR i_decode_stage.fetch_state_i\[3\]
+ sky130_fd_sc_hd__dfrtp_1
X_2417_ i_fwd_unit.mem_stage_i\[0\] i_fwd_unit.mem_stage_i\[39\] VGND VGND VPWR VPWR
+ _0370_ sky130_fd_sc_hd__and2_1
XFILLER_0_58_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3397_ _1193_ _1297_ _0523_ VGND VGND VPWR VPWR _1298_ sky130_fd_sc_hd__mux2_1
X_5136_ clknet_leaf_12_clk_i net371 net293 VGND VGND VPWR VPWR i_mem_slice_stage.mem_state_o\[43\]
+ sky130_fd_sc_hd__dfrtp_1
X_2348_ i_decode_stage.decode_state_o\[127\] net278 VGND VGND VPWR VPWR _2338_ sky130_fd_sc_hd__xor2_2
X_5067_ clknet_leaf_42_clk_i net349 net280 VGND VGND VPWR VPWR i_exec_stage.exec_state_o\[42\]
+ sky130_fd_sc_hd__dfrtp_1
X_4018_ net24 _1829_ _1837_ VGND VGND VPWR VPWR i_mem_slice_stage.pre_data\[30\] sky130_fd_sc_hd__a21o_1
XFILLER_0_79_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_94_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_15_293 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_100_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_97_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_85_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_70_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_38_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_53_344 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3320_ _1219_ _1223_ _0709_ VGND VGND VPWR VPWR _1224_ sky130_fd_sc_hd__mux2_1
XFILLER_0_0_113 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_95_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_403 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_414 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3251_ i_decode_stage.decode_state_o\[238\] i_decode_stage.decode_state_o\[239\]
+ _0408_ VGND VGND VPWR VPWR _1157_ sky130_fd_sc_hd__or3_1
XTAP_425 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_436 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_447 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_458 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3182_ _0344_ _0883_ _1093_ VGND VGND VPWR VPWR _1094_ sky130_fd_sc_hd__a21o_1
XFILLER_0_28_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_469 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_14_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_52 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_17_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_63_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2966_ _0878_ VGND VGND VPWR VPWR net195 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_60_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4705_ net206 i_decode_stage.fetch_state_i\[47\] _1927_ VGND VGND VPWR VPWR _2275_
+ sky130_fd_sc_hd__mux2_1
X_2897_ i_exec_stage.data_fwd_o\[21\] _0726_ _0811_ VGND VGND VPWR VPWR _0812_ sky130_fd_sc_hd__o21ai_4
X_4636_ _2245_ VGND VGND VPWR VPWR _0208_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_44_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4567_ _2211_ VGND VGND VPWR VPWR _0173_ sky130_fd_sc_hd__clkbuf_1
X_3518_ _1370_ _1413_ _0422_ VGND VGND VPWR VPWR _1414_ sky130_fd_sc_hd__mux2_1
X_4498_ i_decode_stage.reg_meta_o\[21\] net105 _2012_ VGND VGND VPWR VPWR _2176_ sky130_fd_sc_hd__mux2_1
X_3449_ _0589_ _0594_ VGND VGND VPWR VPWR _1348_ sky130_fd_sc_hd__nand2_1
XFILLER_0_85_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_970 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5119_ clknet_leaf_14_clk_i i_mem_slice_stage.pre_data\[22\] net294 VGND VGND VPWR
+ VPWR i_mem_slice_stage.mem_state_o\[22\] sky130_fd_sc_hd__dfrtp_1
XTAP_992 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_981 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_119 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_81_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2820_ _2333_ _0730_ _0734_ VGND VGND VPWR VPWR _0735_ sky130_fd_sc_hd__a21o_1
X_2751_ _0346_ i_decode_stage.decode_state_o\[132\] _0347_ _0671_ VGND VGND VPWR VPWR
+ _0672_ sky130_fd_sc_hd__a22oi_4
X_2682_ _0345_ _0603_ _0609_ VGND VGND VPWR VPWR _0610_ sky130_fd_sc_hd__a21o_1
XFILLER_0_81_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_76_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4421_ net215 net216 _2112_ net217 VGND VGND VPWR VPWR _2126_ sky130_fd_sc_hd__a31o_1
X_4352_ net231 _2065_ net201 VGND VGND VPWR VPWR _2072_ sky130_fd_sc_hd__a21oi_1
X_3303_ _1205_ _1206_ _0421_ VGND VGND VPWR VPWR _1207_ sky130_fd_sc_hd__mux2_1
XTAP_211 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_222 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_233 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4283_ _2022_ VGND VGND VPWR VPWR _2023_ sky130_fd_sc_hd__inv_2
X_3234_ _0540_ _1094_ _1139_ _0662_ VGND VGND VPWR VPWR _1140_ sky130_fd_sc_hd__a211o_1
XTAP_266 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_244 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_255 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_299 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_288 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_277 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3165_ _0465_ _0603_ VGND VGND VPWR VPWR _1077_ sky130_fd_sc_hd__and2_1
XFILLER_0_96_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3096_ _0773_ _1006_ _1007_ VGND VGND VPWR VPWR _1008_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_91_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3998_ net5 _1807_ _1813_ _1825_ _1834_ VGND VGND VPWR VPWR i_mem_slice_stage.pre_data\[13\]
+ sky130_fd_sc_hd__a221o_1
XFILLER_0_91_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2949_ _0386_ _0861_ _0862_ _0863_ VGND VGND VPWR VPWR _0864_ sky130_fd_sc_hd__o31ai_4
XFILLER_0_17_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_17_366 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4619_ i_decode_stage.decode_state_o\[123\] net44 _2234_ VGND VGND VPWR VPWR _2238_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_20_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_87_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_472 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_11_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_78_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_25_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_25_87 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4970_ clknet_leaf_9_clk_i _0150_ net292 VGND VGND VPWR VPWR i_decode_stage.reg_meta_o\[31\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_46_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3921_ _0336_ _0969_ _0601_ VGND VGND VPWR VPWR _1787_ sky130_fd_sc_hd__mux2_1
X_3852_ _0738_ _0744_ _0430_ VGND VGND VPWR VPWR _1731_ sky130_fd_sc_hd__a21oi_1
X_2803_ net33 net66 _0720_ VGND VGND VPWR VPWR _0721_ sky130_fd_sc_hd__and3_1
XFILLER_0_41_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3783_ _1359_ _1648_ _1665_ _1350_ VGND VGND VPWR VPWR _1666_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_26_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2734_ _0465_ _0656_ VGND VGND VPWR VPWR _0657_ sky130_fd_sc_hd__and2_1
X_2665_ _0448_ _0591_ _0594_ VGND VGND VPWR VPWR _0595_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_1_230 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4404_ net213 net214 _2105_ VGND VGND VPWR VPWR _2112_ sky130_fd_sc_hd__and3_1
XFILLER_0_41_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2596_ i_mem_slice_stage.mem_state_o\[101\] _0452_ _0533_ _0455_ VGND VGND VPWR VPWR
+ net265 sky130_fd_sc_hd__a22o_1
X_4335_ net228 _2055_ VGND VGND VPWR VPWR _2059_ sky130_fd_sc_hd__nand2_1
XFILLER_0_5_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4266_ _0722_ VGND VGND VPWR VPWR _2012_ sky130_fd_sc_hd__buf_12
X_3217_ _1051_ _1070_ _0540_ VGND VGND VPWR VPWR _1123_ sky130_fd_sc_hd__mux2_1
X_4197_ i_decode_stage.decode_state_o\[42\] i_decode_stage.fetch_state_i\[34\] _1840_
+ VGND VGND VPWR VPWR _1977_ sky130_fd_sc_hd__mux2_1
X_3148_ _1054_ _1059_ _0523_ VGND VGND VPWR VPWR _1060_ sky130_fd_sc_hd__mux2_1
XFILLER_0_49_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3079_ _0989_ _0990_ VGND VGND VPWR VPWR _0991_ sky130_fd_sc_hd__or2_2
XFILLER_0_92_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_87_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_87_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_55_225 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_11_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_70_217 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_23_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_51_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_87_27 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xclkbuf_leaf_13_clk_i clknet_2_2__leaf_clk_i VGND VGND VPWR VPWR clknet_leaf_13_clk_i
+ sky130_fd_sc_hd__clkbuf_16
X_2450_ i_exec_stage.data_fwd_o\[2\] VGND VGND VPWR VPWR _0400_ sky130_fd_sc_hd__inv_1
X_2381_ i_decode_stage.reg_meta_o\[43\] _0317_ _0318_ _0319_ VGND VGND VPWR VPWR _0334_
+ sky130_fd_sc_hd__and4_1
Xclkbuf_leaf_28_clk_i clknet_2_1__leaf_clk_i VGND VGND VPWR VPWR clknet_leaf_28_clk_i
+ sky130_fd_sc_hd__clkbuf_16
X_4120_ i_decode_stage.decode_state_o\[4\] _1929_ _1935_ VGND VGND VPWR VPWR _0002_
+ sky130_fd_sc_hd__a21o_1
X_4051_ _0386_ _0929_ _0930_ _0931_ VGND VGND VPWR VPWR _1869_ sky130_fd_sc_hd__o31ai_2
Xinput5 dmem_rdata_i[13] VGND VGND VPWR VPWR net5 sky130_fd_sc_hd__clkbuf_1
X_3002_ _0324_ _0326_ _0645_ VGND VGND VPWR VPWR _0914_ sky130_fd_sc_hd__or3_2
XFILLER_0_78_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_93_309 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_86_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4953_ clknet_leaf_3_clk_i _0133_ net283 VGND VGND VPWR VPWR i_decode_stage.reg_meta_o\[14\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_74_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3904_ _0519_ VGND VGND VPWR VPWR net189 sky130_fd_sc_hd__inv_2
X_4884_ clknet_leaf_19_clk_i _0064_ net296 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[68\]
+ sky130_fd_sc_hd__dfrtp_1
X_3835_ _0424_ _1714_ _1015_ VGND VGND VPWR VPWR _1715_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_6_333 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_61_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_6_377 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3766_ _1198_ _0779_ VGND VGND VPWR VPWR _1650_ sky130_fd_sc_hd__nand2_1
XFILLER_0_61_239 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2717_ _0465_ _0640_ VGND VGND VPWR VPWR _0641_ sky130_fd_sc_hd__and2_1
X_3697_ _0816_ _1566_ _0815_ VGND VGND VPWR VPWR _1584_ sky130_fd_sc_hd__a21o_1
XFILLER_0_72_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2648_ _0578_ VGND VGND VPWR VPWR net192 sky130_fd_sc_hd__clkinv_2
X_2579_ i_exec_stage.data_fwd_o\[3\] _0332_ _0333_ _0334_ VGND VGND VPWR VPWR _0518_
+ sky130_fd_sc_hd__and4_1
X_4318_ net222 _2045_ VGND VGND VPWR VPWR _2046_ sky130_fd_sc_hd__or2_1
X_5298_ clknet_leaf_10_clk_i _0297_ VGND VGND VPWR VPWR i_exec_stage.data_fwd_o\[32\]
+ sky130_fd_sc_hd__dfxtp_1
X_4249_ _2003_ VGND VGND VPWR VPWR _0063_ sky130_fd_sc_hd__clkbuf_1
XTAP_1004 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_1037 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1026 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1015 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_1059 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1048 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_37_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_52_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_20_103 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_28_214 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3620_ _0958_ _0975_ _0995_ VGND VGND VPWR VPWR _1511_ sky130_fd_sc_hd__o21ba_1
X_3551_ _0832_ _0841_ _0842_ VGND VGND VPWR VPWR _1445_ sky130_fd_sc_hd__o21a_1
X_2502_ _0449_ VGND VGND VPWR VPWR _0450_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_51_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_11_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3482_ _0417_ _0656_ _1379_ _0413_ _0424_ VGND VGND VPWR VPWR _1380_ sky130_fd_sc_hd__o221a_1
XFILLER_0_11_169 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5221_ clknet_leaf_29_clk_i _0220_ net286 VGND VGND VPWR VPWR i_decode_stage.fetch_state_i\[19\]
+ sky130_fd_sc_hd__dfrtp_1
X_2433_ _0332_ _0333_ _0334_ VGND VGND VPWR VPWR _0385_ sky130_fd_sc_hd__and3_1
X_2364_ i_decode_stage.decode_state_o\[124\] i_exec_stage.data_fwd_o\[33\] VGND VGND
+ VPWR VPWR _0318_ sky130_fd_sc_hd__or2b_1
X_5152_ clknet_leaf_11_clk_i net378 net297 VGND VGND VPWR VPWR i_mem_slice_stage.mem_state_o\[59\]
+ sky130_fd_sc_hd__dfrtp_1
X_4103_ _1902_ _1852_ _1879_ _1920_ VGND VGND VPWR VPWR _1921_ sky130_fd_sc_hd__or4_1
X_5083_ clknet_leaf_32_clk_i i_decode_stage.decode_state_o\[27\] net286 VGND VGND
+ VPWR VPWR i_exec_stage.exec_state_o\[58\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_37_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4034_ _1841_ _1842_ _1847_ _1851_ VGND VGND VPWR VPWR _1852_ sky130_fd_sc_hd__or4_1
XFILLER_0_66_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_93_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4936_ clknet_leaf_26_clk_i _0116_ net289 VGND VGND VPWR VPWR net220 sky130_fd_sc_hd__dfrtp_2
XANTENNA_10 _0608_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4867_ clknet_leaf_29_clk_i _0047_ net285 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[51\]
+ sky130_fd_sc_hd__dfrtp_1
XANTENNA_21 net43 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_32 net137 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3818_ _1661_ _1698_ _0422_ VGND VGND VPWR VPWR _1699_ sky130_fd_sc_hd__mux2_1
XANTENNA_54 net230 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_65 i_decode_stage.decode_state_o\[138\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_43 net155 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_87 net228 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_76 net134 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4798_ _2321_ VGND VGND VPWR VPWR _0294_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_15_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3749_ _0411_ _1619_ _1622_ _1633_ VGND VGND VPWR VPWR net145 sky130_fd_sc_hd__a211o_4
XFILLER_0_100_333 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xoutput161 net161 VGND VGND VPWR VPWR dmem_addr_o[9] sky130_fd_sc_hd__clkbuf_4
Xoutput150 net150 VGND VGND VPWR VPWR dmem_addr_o[28] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_100_377 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xoutput183 net183 VGND VGND VPWR VPWR dmem_wdata_o[24] sky130_fd_sc_hd__clkbuf_4
Xoutput172 net172 VGND VGND VPWR VPWR dmem_wdata_o[14] sky130_fd_sc_hd__clkbuf_4
Xoutput194 net194 VGND VGND VPWR VPWR dmem_wdata_o[5] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_69_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_65_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_607 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_618 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_629 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_489 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2982_ _0525_ _0893_ _0887_ VGND VGND VPWR VPWR _0894_ sky130_fd_sc_hd__or3_1
XFILLER_0_8_406 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4721_ net215 i_decode_stage.fetch_state_i\[55\] _1927_ VGND VGND VPWR VPWR _2283_
+ sky130_fd_sc_hd__mux2_1
X_4652_ _2253_ VGND VGND VPWR VPWR _0216_ sky130_fd_sc_hd__clkbuf_1
Xinput30 dmem_rdata_i[7] VGND VGND VPWR VPWR net30 sky130_fd_sc_hd__clkbuf_1
X_3603_ _0958_ _0975_ _1494_ VGND VGND VPWR VPWR _1495_ sky130_fd_sc_hd__o21a_1
Xinput52 imem_rdata_i[26] VGND VGND VPWR VPWR net52 sky130_fd_sc_hd__clkbuf_1
Xinput41 imem_rdata_i[16] VGND VGND VPWR VPWR net41 sky130_fd_sc_hd__clkbuf_4
Xinput63 imem_rdata_i[7] VGND VGND VPWR VPWR net63 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_3_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4583_ _2219_ VGND VGND VPWR VPWR _0181_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_71_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_445 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xinput74 rf_rs1_i[16] VGND VGND VPWR VPWR net74 sky130_fd_sc_hd__clkbuf_1
Xinput96 rf_rs1_i[7] VGND VGND VPWR VPWR net96 sky130_fd_sc_hd__clkbuf_1
Xinput85 rf_rs1_i[26] VGND VGND VPWR VPWR net85 sky130_fd_sc_hd__clkbuf_1
X_3534_ _0939_ _1405_ _0843_ VGND VGND VPWR VPWR _1429_ sky130_fd_sc_hd__o21a_1
XFILLER_0_12_489 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3465_ _1344_ _1345_ _1363_ VGND VGND VPWR VPWR net161 sky130_fd_sc_hd__a21o_2
X_2416_ _0368_ VGND VGND VPWR VPWR _0369_ sky130_fd_sc_hd__buf_2
X_5204_ clknet_leaf_39_clk_i _0203_ net285 VGND VGND VPWR VPWR i_decode_stage.fetch_state_i\[2\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_58_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3396_ _0540_ _1295_ _1296_ VGND VGND VPWR VPWR _1297_ sky130_fd_sc_hd__o21ai_1
X_5135_ clknet_leaf_12_clk_i net376 net293 VGND VGND VPWR VPWR i_mem_slice_stage.mem_state_o\[42\]
+ sky130_fd_sc_hd__dfrtp_1
X_2347_ i_decode_stage.decode_state_o\[128\] net279 VGND VGND VPWR VPWR _2337_ sky130_fd_sc_hd__xor2_2
XFILLER_0_35_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5066_ clknet_leaf_41_clk_i i_decode_stage.decode_state_o\[10\] net280 VGND VGND
+ VPWR VPWR i_exec_stage.exec_state_o\[41\] sky130_fd_sc_hd__dfrtp_1
X_4017_ net22 _1829_ _1837_ VGND VGND VPWR VPWR i_mem_slice_stage.pre_data\[29\] sky130_fd_sc_hd__a21o_1
XFILLER_0_74_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_71 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4919_ clknet_leaf_31_clk_i _0099_ net285 VGND VGND VPWR VPWR net202 sky130_fd_sc_hd__dfrtp_2
XFILLER_0_74_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_7_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xclkbuf_2_2__f_clk_i clknet_0_clk_i VGND VGND VPWR VPWR clknet_2_2__leaf_clk_i sky130_fd_sc_hd__clkbuf_16
XFILLER_0_30_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_85_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_57_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_53_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_125 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_0_169 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_404 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_415 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_426 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_437 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_448 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3250_ _1155_ VGND VGND VPWR VPWR _1156_ sky130_fd_sc_hd__buf_6
X_3181_ _0343_ _1092_ VGND VGND VPWR VPWR _1093_ sky130_fd_sc_hd__nor2_1
XTAP_459 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_44_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_8_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4704_ _2274_ VGND VGND VPWR VPWR _0247_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_8_269 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2965_ _0877_ i_exec_stage.data_fwd_o\[7\] _0439_ VGND VGND VPWR VPWR _0878_ sky130_fd_sc_hd__mux2_1
X_2896_ i_decode_stage.reg_meta_o\[26\] _0727_ _0386_ _0810_ VGND VGND VPWR VPWR _0811_
+ sky130_fd_sc_hd__a211o_1
X_4635_ i_decode_stage.fetch_state_i\[7\] _2063_ _2234_ VGND VGND VPWR VPWR _2245_
+ sky130_fd_sc_hd__mux2_1
X_4566_ i_decode_stage.reg_meta_o\[54\] net68 _2207_ VGND VGND VPWR VPWR _2211_ sky130_fd_sc_hd__mux2_1
XFILLER_0_4_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3517_ _0344_ _0640_ _1082_ VGND VGND VPWR VPWR _1413_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_12_253 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4497_ _2175_ VGND VGND VPWR VPWR _0139_ sky130_fd_sc_hd__clkbuf_1
X_3448_ _0944_ _1317_ _0920_ VGND VGND VPWR VPWR _1347_ sky130_fd_sc_hd__o21ai_1
XTAP_971 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_960 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3379_ _0582_ _0712_ VGND VGND VPWR VPWR _1281_ sky130_fd_sc_hd__nor2_2
X_5118_ clknet_leaf_14_clk_i i_mem_slice_stage.pre_data\[21\] net294 VGND VGND VPWR
+ VPWR i_mem_slice_stage.mem_state_o\[21\] sky130_fd_sc_hd__dfrtp_1
XTAP_993 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_982 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5049_ clknet_leaf_11_clk_i net139 net292 VGND VGND VPWR VPWR i_exec_stage.exec_state_o\[24\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_94_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_67_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2750_ _0358_ _0668_ _0669_ _0670_ VGND VGND VPWR VPWR _0671_ sky130_fd_sc_hd__o31a_2
X_2681_ _0465_ _0608_ VGND VGND VPWR VPWR _0609_ sky130_fd_sc_hd__and2_1
XFILLER_0_81_473 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_5_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4420_ net216 net217 _2117_ VGND VGND VPWR VPWR _2125_ sky130_fd_sc_hd__and3_1
XFILLER_0_41_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_53_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4351_ net231 net201 _2065_ VGND VGND VPWR VPWR _2071_ sky130_fd_sc_hd__and3_1
XFILLER_0_69_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3302_ _0691_ _0695_ _0344_ VGND VGND VPWR VPWR _1206_ sky130_fd_sc_hd__mux2_1
XTAP_212 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_223 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4282_ _1930_ _1938_ _2020_ _2021_ VGND VGND VPWR VPWR _2022_ sky130_fd_sc_hd__a211o_1
X_3233_ _0540_ _1097_ VGND VGND VPWR VPWR _1139_ sky130_fd_sc_hd__nor2_1
XTAP_234 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_245 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_256 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_289 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_278 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_267 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3164_ _0345_ _0608_ _1075_ VGND VGND VPWR VPWR _1076_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_55_96 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3095_ _0563_ _0770_ VGND VGND VPWR VPWR _1007_ sky130_fd_sc_hd__and2b_1
X_3997_ net4 _1807_ _1813_ _1823_ _1834_ VGND VGND VPWR VPWR i_mem_slice_stage.pre_data\[12\]
+ sky130_fd_sc_hd__a221o_1
XFILLER_0_29_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2948_ i_exec_stage.data_fwd_o\[6\] _0311_ _0316_ _0320_ VGND VGND VPWR VPWR _0863_
+ sky130_fd_sc_hd__or4_1
X_4618_ _2237_ VGND VGND VPWR VPWR _0198_ sky130_fd_sc_hd__clkbuf_1
X_2879_ i_exec_stage.data_fwd_o\[23\] _0726_ _0793_ VGND VGND VPWR VPWR _0794_ sky130_fd_sc_hd__o21ai_4
X_4549_ i_decode_stage.reg_meta_o\[46\] net89 _2179_ VGND VGND VPWR VPWR _2202_ sky130_fd_sc_hd__mux2_1
XFILLER_0_99_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_99_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_99_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_790 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_48_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_35_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_23_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_35_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_2_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_50_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_63_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3920_ _1785_ _1106_ _1786_ VGND VGND VPWR VPWR net173 sky130_fd_sc_hd__o21ai_1
XFILLER_0_25_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_58_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3851_ _0738_ _0744_ _1723_ VGND VGND VPWR VPWR _1730_ sky130_fd_sc_hd__or3_1
XFILLER_0_41_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3782_ _0712_ _1664_ _1129_ VGND VGND VPWR VPWR _1665_ sky130_fd_sc_hd__o21ai_1
X_2802_ _0439_ _0358_ i_exec_stage.data_fwd_o\[38\] VGND VGND VPWR VPWR _0720_ sky130_fd_sc_hd__o21ai_4
XFILLER_0_41_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_73_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2733_ _0346_ i_decode_stage.decode_state_o\[134\] _0347_ _0655_ VGND VGND VPWR VPWR
+ _0656_ sky130_fd_sc_hd__a22oi_4
X_2664_ i_decode_stage.decode_state_o\[239\] _0593_ VGND VGND VPWR VPWR _0594_ sky130_fd_sc_hd__nor2_4
X_2595_ i_mem_slice_stage.mem_state_o\[69\] i_mem_slice_stage.mem_state_o\[30\] _0453_
+ VGND VGND VPWR VPWR _0533_ sky130_fd_sc_hd__mux2_2
XFILLER_0_10_510 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_1_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4403_ net213 _1929_ _2111_ VGND VGND VPWR VPWR _0109_ sky130_fd_sc_hd__a21o_1
X_4334_ net157 _2047_ _2048_ _2057_ _2058_ VGND VGND VPWR VPWR _0093_ sky130_fd_sc_hd__o221a_1
XFILLER_0_1_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4265_ _2011_ VGND VGND VPWR VPWR _0071_ sky130_fd_sc_hd__clkbuf_1
X_3216_ _0540_ _1056_ _1121_ VGND VGND VPWR VPWR _1122_ sky130_fd_sc_hd__o21ai_1
X_4196_ _1976_ VGND VGND VPWR VPWR _0037_ sky130_fd_sc_hd__clkbuf_1
X_3147_ _1056_ _1058_ _0421_ VGND VGND VPWR VPWR _1059_ sky130_fd_sc_hd__mux2_1
X_3078_ _0507_ _0988_ VGND VGND VPWR VPWR _0990_ sky130_fd_sc_hd__and2_1
XFILLER_0_37_418 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_49_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_17_131 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_45_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_60_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_leaf_9_clk_i clknet_2_2__leaf_clk_i VGND VGND VPWR VPWR clknet_leaf_9_clk_i
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_99_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_70_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_87_39 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_23_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2380_ _0312_ _0313_ _0314_ _0315_ VGND VGND VPWR VPWR _0333_ sky130_fd_sc_hd__and4_1
X_4050_ _0726_ _0914_ _0915_ _0916_ VGND VGND VPWR VPWR _1868_ sky130_fd_sc_hd__a31o_1
Xinput6 dmem_rdata_i[14] VGND VGND VPWR VPWR net6 sky130_fd_sc_hd__clkbuf_1
X_3001_ _0911_ _0912_ VGND VGND VPWR VPWR _0913_ sky130_fd_sc_hd__nor2_2
X_4952_ clknet_leaf_3_clk_i _0132_ net283 VGND VGND VPWR VPWR i_decode_stage.reg_meta_o\[13\]
+ sky130_fd_sc_hd__dfrtp_1
X_4883_ clknet_leaf_20_clk_i _0063_ net296 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[67\]
+ sky130_fd_sc_hd__dfrtp_1
X_3903_ _0917_ _1774_ _1776_ VGND VGND VPWR VPWR net198 sky130_fd_sc_hd__a21o_1
X_3834_ _0417_ _0556_ _1014_ _0415_ _1713_ VGND VGND VPWR VPWR _1714_ sky130_fd_sc_hd__o221a_1
XFILLER_0_46_259 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3765_ _1129_ _1324_ _1647_ _1648_ _1331_ VGND VGND VPWR VPWR _1649_ sky130_fd_sc_hd__a32o_1
XFILLER_0_6_345 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_6_389 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2716_ _0450_ _0638_ _0639_ _0492_ VGND VGND VPWR VPWR _0640_ sky130_fd_sc_hd__a2bb2o_4
X_3696_ _0411_ _1567_ _1580_ _1583_ VGND VGND VPWR VPWR net142 sky130_fd_sc_hd__a211o_4
X_2647_ _0322_ _0574_ _0576_ _0577_ VGND VGND VPWR VPWR _0578_ sky130_fd_sc_hd__a31oi_4
XFILLER_0_65_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_10_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2578_ _0324_ _0326_ net264 VGND VGND VPWR VPWR _0517_ sky130_fd_sc_hd__or3_1
X_4317_ _2044_ VGND VGND VPWR VPWR _2045_ sky130_fd_sc_hd__clkbuf_4
X_5297_ clknet_leaf_10_clk_i _0296_ VGND VGND VPWR VPWR i_exec_stage.data_fwd_o\[31\]
+ sky130_fd_sc_hd__dfxtp_1
X_4248_ i_decode_stage.decode_state_o\[67\] i_decode_stage.fetch_state_i\[59\] _1982_
+ VGND VGND VPWR VPWR _2003_ sky130_fd_sc_hd__mux2_1
X_4179_ i_decode_stage.fetch_state_i\[25\] i_decode_stage.decode_state_o\[33\] _1967_
+ VGND VGND VPWR VPWR _1968_ sky130_fd_sc_hd__mux2_1
XFILLER_0_96_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_1038 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1027 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1016 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1005 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1049 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_92_376 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_92_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_9_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_45_281 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_52_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_33_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_115 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_28_226 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_98_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3550_ _0841_ _0842_ _0834_ VGND VGND VPWR VPWR _1444_ sky130_fd_sc_hd__and3b_1
XFILLER_0_3_337 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2501_ _0346_ i_decode_stage.decode_state_o\[234\] VGND VGND VPWR VPWR _0449_ sky130_fd_sc_hd__or2_1
XFILLER_0_51_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5220_ clknet_leaf_33_clk_i _0219_ net287 VGND VGND VPWR VPWR i_decode_stage.fetch_state_i\[18\]
+ sky130_fd_sc_hd__dfrtp_1
X_3481_ _0656_ _0934_ VGND VGND VPWR VPWR _1379_ sky130_fd_sc_hd__nor2_1
X_2432_ _0383_ VGND VGND VPWR VPWR _0384_ sky130_fd_sc_hd__buf_6
X_2363_ i_exec_stage.data_fwd_o\[33\] i_decode_stage.decode_state_o\[124\] VGND VGND
+ VPWR VPWR _0317_ sky130_fd_sc_hd__or2b_1
X_5151_ clknet_leaf_11_clk_i net369 net297 VGND VGND VPWR VPWR i_mem_slice_stage.mem_state_o\[58\]
+ sky130_fd_sc_hd__dfrtp_1
X_5082_ clknet_leaf_33_clk_i i_decode_stage.decode_state_o\[26\] net287 VGND VGND
+ VPWR VPWR i_exec_stage.exec_state_o\[57\] sky130_fd_sc_hd__dfrtp_1
X_4102_ _1916_ _1917_ _1919_ VGND VGND VPWR VPWR _1920_ sky130_fd_sc_hd__or3_1
X_4033_ _1848_ _1849_ _1850_ VGND VGND VPWR VPWR _1851_ sky130_fd_sc_hd__or3b_1
XFILLER_0_63_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4935_ clknet_leaf_20_clk_i _0115_ net296 VGND VGND VPWR VPWR net219 sky130_fd_sc_hd__dfrtp_4
XFILLER_0_74_365 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XANTENNA_22 net47 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4866_ clknet_leaf_33_clk_i _0046_ net287 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[50\]
+ sky130_fd_sc_hd__dfrtp_1
XANTENNA_11 _0730_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3817_ _1697_ VGND VGND VPWR VPWR _1698_ sky130_fd_sc_hd__inv_2
XANTENNA_44 net158 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_55 net231 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_66 i_exec_stage.alu_out\[0\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_33 net142 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4797_ i_exec_stage.data_fwd_o\[29\] net150 _1838_ VGND VGND VPWR VPWR _2321_ sky130_fd_sc_hd__mux2_1
XANTENNA_88 net263 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_77 net143 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3748_ _1129_ _1628_ _1631_ _0790_ _1632_ VGND VGND VPWR VPWR _1633_ sky130_fd_sc_hd__a221o_1
XFILLER_0_6_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_88_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3679_ _0817_ _1566_ VGND VGND VPWR VPWR _1567_ sky130_fd_sc_hd__xnor2_1
Xoutput140 net140 VGND VGND VPWR VPWR dmem_addr_o[18] sky130_fd_sc_hd__clkbuf_4
Xoutput151 net151 VGND VGND VPWR VPWR dmem_addr_o[29] sky130_fd_sc_hd__buf_2
XFILLER_0_100_345 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xoutput184 net184 VGND VGND VPWR VPWR dmem_wdata_o[25] sky130_fd_sc_hd__clkbuf_4
Xoutput173 net173 VGND VGND VPWR VPWR dmem_wdata_o[15] sky130_fd_sc_hd__clkbuf_4
Xoutput195 net195 VGND VGND VPWR VPWR dmem_wdata_o[6] sky130_fd_sc_hd__clkbuf_4
Xoutput162 net162 VGND VGND VPWR VPWR dmem_be_o[0] sky130_fd_sc_hd__clkbuf_4
X_5349_ net42 VGND VGND VPWR VPWR net234 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_100_389 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xclkbuf_leaf_12_clk_i clknet_2_2__leaf_clk_i VGND VGND VPWR VPWR clknet_leaf_12_clk_i
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_69_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_77_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_80_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_leaf_27_clk_i clknet_2_1__leaf_clk_i VGND VGND VPWR VPWR clknet_leaf_27_clk_i
+ sky130_fd_sc_hd__clkbuf_16
XTAP_608 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_619 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2981_ _0703_ VGND VGND VPWR VPWR _0893_ sky130_fd_sc_hd__inv_2
XFILLER_0_8_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_68_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4720_ _2282_ VGND VGND VPWR VPWR _0255_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_56_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4651_ i_decode_stage.fetch_state_i\[15\] _2089_ _2234_ VGND VGND VPWR VPWR _2253_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_71_324 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xinput20 dmem_rdata_i[27] VGND VGND VPWR VPWR net20 sky130_fd_sc_hd__clkbuf_1
Xinput31 dmem_rdata_i[8] VGND VGND VPWR VPWR net31 sky130_fd_sc_hd__clkbuf_1
X_3602_ _0958_ _0975_ _0430_ VGND VGND VPWR VPWR _1494_ sky130_fd_sc_hd__a21oi_1
Xinput53 imem_rdata_i[27] VGND VGND VPWR VPWR net53 sky130_fd_sc_hd__clkbuf_1
Xinput42 imem_rdata_i[17] VGND VGND VPWR VPWR net42 sky130_fd_sc_hd__clkbuf_4
Xinput64 imem_rdata_i[8] VGND VGND VPWR VPWR net64 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_24_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4582_ i_decode_stage.reg_meta_o\[62\] net76 _2207_ VGND VGND VPWR VPWR _2219_ sky130_fd_sc_hd__mux2_1
XFILLER_0_101_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_3_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput97 rf_rs1_i[8] VGND VGND VPWR VPWR net97 sky130_fd_sc_hd__clkbuf_1
Xinput75 rf_rs1_i[17] VGND VGND VPWR VPWR net75 sky130_fd_sc_hd__clkbuf_1
Xinput86 rf_rs1_i[27] VGND VGND VPWR VPWR net86 sky130_fd_sc_hd__clkbuf_1
X_3533_ _0843_ _1427_ VGND VGND VPWR VPWR _1428_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_12_457 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3464_ _1156_ _1346_ _1347_ _1362_ VGND VGND VPWR VPWR _1363_ sky130_fd_sc_hd__a31o_1
X_2415_ _0364_ _0365_ _0366_ _0367_ VGND VGND VPWR VPWR _0368_ sky130_fd_sc_hd__and4_1
X_5203_ clknet_leaf_32_clk_i _0202_ net287 VGND VGND VPWR VPWR net211 sky130_fd_sc_hd__dfrtp_2
X_3395_ _0421_ _1239_ VGND VGND VPWR VPWR _1296_ sky130_fd_sc_hd__or2_1
X_5134_ clknet_leaf_12_clk_i net370 net293 VGND VGND VPWR VPWR i_mem_slice_stage.mem_state_o\[41\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_58_85 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2346_ _2334_ _2335_ VGND VGND VPWR VPWR _2336_ sky130_fd_sc_hd__nor2_8
X_5065_ clknet_leaf_34_clk_i i_decode_stage.decode_state_o\[41\] net284 VGND VGND
+ VPWR VPWR i_exec_stage.exec_state_o\[40\] sky130_fd_sc_hd__dfrtp_1
X_4016_ net21 _1829_ _1837_ VGND VGND VPWR VPWR i_mem_slice_stage.pre_data\[28\] sky130_fd_sc_hd__a21o_1
XFILLER_0_59_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_90_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4918_ clknet_leaf_31_clk_i _0098_ net285 VGND VGND VPWR VPWR net201 sky130_fd_sc_hd__dfrtp_2
XFILLER_0_35_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_473 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4849_ clknet_leaf_28_clk_i _0029_ net290 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[33\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_85_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_38_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_65_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_405 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_416 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_427 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_438 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_449 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3180_ _0346_ i_decode_stage.decode_state_o\[129\] _0347_ _1091_ VGND VGND VPWR VPWR
+ _1092_ sky130_fd_sc_hd__a22o_1
XFILLER_0_28_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_48_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_490 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_91_408 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_17_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_29_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2964_ i_decode_stage.reg_meta_o\[12\] net270 _0441_ VGND VGND VPWR VPWR _0877_ sky130_fd_sc_hd__mux2_1
X_4703_ net205 i_decode_stage.fetch_state_i\[46\] _1927_ VGND VGND VPWR VPWR _2274_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_44_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2895_ _2336_ _2341_ net254 VGND VGND VPWR VPWR _0810_ sky130_fd_sc_hd__and3_1
XFILLER_0_71_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4634_ _2244_ VGND VGND VPWR VPWR _0207_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_4_421 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4565_ _2210_ VGND VGND VPWR VPWR _0172_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_12_221 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3516_ _0590_ _0712_ VGND VGND VPWR VPWR _1412_ sky130_fd_sc_hd__nor2_1
XFILLER_0_100_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4496_ i_decode_stage.reg_meta_o\[20\] net104 _2012_ VGND VGND VPWR VPWR _2175_ sky130_fd_sc_hd__mux2_1
X_3447_ _0920_ _0944_ _1317_ VGND VGND VPWR VPWR _1346_ sky130_fd_sc_hd__or3_1
X_3378_ _0662_ _1136_ _1279_ VGND VGND VPWR VPWR _1280_ sky130_fd_sc_hd__a21oi_1
XTAP_961 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_950 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5117_ clknet_leaf_14_clk_i i_mem_slice_stage.pre_data\[20\] net294 VGND VGND VPWR
+ VPWR i_mem_slice_stage.mem_state_o\[20\] sky130_fd_sc_hd__dfrtp_1
XTAP_994 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_983 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_972 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5048_ clknet_leaf_11_clk_i net138 net292 VGND VGND VPWR VPWR i_exec_stage.exec_state_o\[23\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_67_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_79_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_151 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_62_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_7_281 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_101_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_58_405 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_14_35 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_58_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_58_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_73_419 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_30_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_53_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_26_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2680_ _0450_ _0606_ _0492_ _0607_ VGND VGND VPWR VPWR _0608_ sky130_fd_sc_hd__a2bb2o_4
XFILLER_0_53_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_81_485 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4350_ net161 _2047_ _2048_ _2069_ _2070_ VGND VGND VPWR VPWR _0097_ sky130_fd_sc_hd__o221a_1
X_3301_ _1152_ VGND VGND VPWR VPWR _1205_ sky130_fd_sc_hd__inv_1
XFILLER_0_39_21 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_213 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_224 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4281_ net59 _1937_ _1938_ VGND VGND VPWR VPWR _2021_ sky130_fd_sc_hd__and3_1
X_3232_ _1081_ _1090_ _0422_ VGND VGND VPWR VPWR _1138_ sky130_fd_sc_hd__mux2_1
XTAP_235 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_246 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_257 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3163_ _0465_ _0617_ VGND VGND VPWR VPWR _1075_ sky130_fd_sc_hd__and2_1
XTAP_279 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_268 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3094_ _0470_ _0778_ VGND VGND VPWR VPWR _1006_ sky130_fd_sc_hd__and2b_1
XFILLER_0_49_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3996_ net3 _1807_ _1813_ _1821_ _1834_ VGND VGND VPWR VPWR i_mem_slice_stage.pre_data\[11\]
+ sky130_fd_sc_hd__a221o_1
XFILLER_0_76_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_91_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2947_ _0324_ _0326_ i_decode_stage.reg_meta_o\[11\] VGND VGND VPWR VPWR _0862_ sky130_fd_sc_hd__o21a_1
X_4617_ i_decode_stage.decode_state_o\[122\] net43 _2234_ VGND VGND VPWR VPWR _2237_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_4_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2878_ i_decode_stage.reg_meta_o\[28\] _0727_ _0386_ _0792_ VGND VGND VPWR VPWR _0793_
+ sky130_fd_sc_hd__a211o_1
XFILLER_0_4_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4548_ _2201_ VGND VGND VPWR VPWR _0164_ sky130_fd_sc_hd__clkbuf_1
X_4479_ _2166_ VGND VGND VPWR VPWR _0130_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_96_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_780 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_791 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_393 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_101_281 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_25_34 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3850_ _0738_ _1727_ _1158_ VGND VGND VPWR VPWR _1729_ sky130_fd_sc_hd__a21oi_1
X_3781_ _1519_ _1663_ _0590_ VGND VGND VPWR VPWR _1664_ sky130_fd_sc_hd__mux2_1
X_2801_ _0719_ VGND VGND VPWR VPWR i_exec_stage.alu_out\[1\] sky130_fd_sc_hd__buf_4
XFILLER_0_6_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2732_ _0358_ _0652_ _0653_ _0654_ VGND VGND VPWR VPWR _0655_ sky130_fd_sc_hd__o31a_2
XFILLER_0_54_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_81_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2663_ i_decode_stage.decode_state_o\[238\] _0592_ VGND VGND VPWR VPWR _0593_ sky130_fd_sc_hd__nand2_2
X_4402_ net143 _1924_ _2042_ _2110_ VGND VGND VPWR VPWR _2111_ sky130_fd_sc_hd__o22a_1
X_2594_ _0451_ _0530_ _0462_ _0531_ VGND VGND VPWR VPWR _0532_ sky130_fd_sc_hd__a2bb2o_2
X_4333_ net227 _1840_ VGND VGND VPWR VPWR _2058_ sky130_fd_sc_hd__or2_1
XFILLER_0_22_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4264_ i_decode_stage.decode_state_o\[129\] net51 _1982_ VGND VGND VPWR VPWR _2011_
+ sky130_fd_sc_hd__mux2_1
X_3215_ _0422_ _1053_ VGND VGND VPWR VPWR _1121_ sky130_fd_sc_hd__or2_1
XFILLER_0_5_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4195_ i_decode_stage.decode_state_o\[41\] i_decode_stage.fetch_state_i\[1\] _1840_
+ VGND VGND VPWR VPWR _1976_ sky130_fd_sc_hd__mux2_1
X_3146_ _0345_ _0622_ _1057_ VGND VGND VPWR VPWR _1058_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_77_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3077_ _0507_ _0988_ VGND VGND VPWR VPWR _0989_ sky130_fd_sc_hd__nor2_2
XFILLER_0_77_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3979_ net27 _1809_ _1824_ VGND VGND VPWR VPWR i_mem_slice_stage.pre_data\[4\] sky130_fd_sc_hd__a21o_1
XFILLER_0_17_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_45_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_17_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_60_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_13_393 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_99_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_68_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_83_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput7 dmem_rdata_i[15] VGND VGND VPWR VPWR net7 sky130_fd_sc_hd__clkbuf_1
X_3000_ _0672_ _0910_ VGND VGND VPWR VPWR _0912_ sky130_fd_sc_hd__and2_1
XFILLER_0_36_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4951_ clknet_leaf_2_clk_i _0131_ net283 VGND VGND VPWR VPWR i_decode_stage.reg_meta_o\[12\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_86_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4882_ clknet_leaf_20_clk_i _0062_ net296 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[66\]
+ sky130_fd_sc_hd__dfrtp_1
X_3902_ _0391_ _1774_ VGND VGND VPWR VPWR _1776_ sky130_fd_sc_hd__nor2_1
X_3833_ _1198_ _1014_ VGND VGND VPWR VPWR _1713_ sky130_fd_sc_hd__nand2_1
X_3764_ _1501_ VGND VGND VPWR VPWR _1648_ sky130_fd_sc_hd__inv_2
XFILLER_0_6_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2715_ i_decode_stage.decode_state_o\[0\] _0493_ VGND VGND VPWR VPWR _0639_ sky130_fd_sc_hd__nand2_1
XFILLER_0_54_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3695_ _0817_ _1581_ _1582_ VGND VGND VPWR VPWR _1583_ sky130_fd_sc_hd__o21a_1
X_2646_ i_exec_stage.data_fwd_o\[4\] _0332_ _0333_ _0334_ VGND VGND VPWR VPWR _0577_
+ sky130_fd_sc_hd__and4_1
XFILLER_0_42_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2577_ i_mem_slice_stage.mem_state_o\[73\] _0328_ _0516_ _0330_ VGND VGND VPWR VPWR
+ net264 sky130_fd_sc_hd__a22o_1
XFILLER_0_10_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_58_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_10_374 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4316_ _0722_ _1924_ VGND VGND VPWR VPWR _2044_ sky130_fd_sc_hd__and2_1
X_5296_ clknet_leaf_8_clk_i _0295_ VGND VGND VPWR VPWR i_exec_stage.data_fwd_o\[30\]
+ sky130_fd_sc_hd__dfxtp_1
X_4247_ _2002_ VGND VGND VPWR VPWR _0062_ sky130_fd_sc_hd__clkbuf_1
X_4178_ _1926_ VGND VGND VPWR VPWR _1967_ sky130_fd_sc_hd__buf_12
XFILLER_0_93_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3129_ _1040_ VGND VGND VPWR VPWR _1041_ sky130_fd_sc_hd__clkbuf_4
XTAP_1028 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1017 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1006 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1039 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_65_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_388 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_45_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_20_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_20_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_68_330 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_56_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_83_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2500_ _0447_ VGND VGND VPWR VPWR _0448_ sky130_fd_sc_hd__buf_8
XFILLER_0_3_349 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_24_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3480_ _0935_ _0946_ _1347_ _0430_ VGND VGND VPWR VPWR _1378_ sky130_fd_sc_hd__a31o_1
XFILLER_0_51_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2431_ i_decode_stage.decode_state_o\[233\] i_decode_stage.decode_state_o\[232\]
+ VGND VGND VPWR VPWR _0383_ sky130_fd_sc_hd__or2_1
X_2362_ _0312_ _0313_ _0314_ _0315_ VGND VGND VPWR VPWR _0316_ sky130_fd_sc_hd__nand4_2
X_5150_ clknet_leaf_10_clk_i net390 net297 VGND VGND VPWR VPWR i_mem_slice_stage.mem_state_o\[57\]
+ sky130_fd_sc_hd__dfrtp_1
X_5081_ clknet_leaf_31_clk_i i_decode_stage.decode_state_o\[25\] net286 VGND VGND
+ VPWR VPWR i_exec_stage.exec_state_o\[56\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_47_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4101_ _1855_ _1863_ _1918_ _1854_ VGND VGND VPWR VPWR _1919_ sky130_fd_sc_hd__or4b_1
XFILLER_0_47_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4032_ _0481_ _0794_ _0803_ _0475_ VGND VGND VPWR VPWR _1850_ sky130_fd_sc_hd__o22a_1
X_4934_ clknet_leaf_26_clk_i _0114_ net289 VGND VGND VPWR VPWR net218 sky130_fd_sc_hd__dfrtp_2
XFILLER_0_86_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4865_ clknet_leaf_38_clk_i _0045_ net285 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[49\]
+ sky130_fd_sc_hd__dfrtp_1
XANTENNA_23 net48 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_12 _0776_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3816_ _0345_ _0551_ _0569_ VGND VGND VPWR VPWR _1697_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_74_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_56 net261 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_45 net159 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_34 net142 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
Xclkbuf_leaf_8_clk_i clknet_2_2__leaf_clk_i VGND VGND VPWR VPWR clknet_leaf_8_clk_i
+ sky130_fd_sc_hd__clkbuf_16
X_4796_ _2320_ VGND VGND VPWR VPWR _0293_ sky130_fd_sc_hd__clkbuf_1
X_3747_ _1299_ _1313_ _0448_ VGND VGND VPWR VPWR _1632_ sky130_fd_sc_hd__o21a_1
XANTENNA_89 net278 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_67 i_exec_stage.alu_out\[0\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_78 net143 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3678_ _1492_ _1563_ _1565_ VGND VGND VPWR VPWR _1566_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_88_94 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xoutput152 net152 VGND VGND VPWR VPWR dmem_addr_o[2] sky130_fd_sc_hd__buf_2
X_2629_ _0346_ i_decode_stage.decode_state_o\[129\] VGND VGND VPWR VPWR _0562_ sky130_fd_sc_hd__or2b_1
Xoutput141 net141 VGND VGND VPWR VPWR dmem_addr_o[19] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_100_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xoutput185 net185 VGND VGND VPWR VPWR dmem_wdata_o[26] sky130_fd_sc_hd__clkbuf_4
Xoutput174 net174 VGND VGND VPWR VPWR dmem_wdata_o[16] sky130_fd_sc_hd__clkbuf_4
Xoutput163 net163 VGND VGND VPWR VPWR dmem_be_o[1] sky130_fd_sc_hd__clkbuf_4
X_5348_ net41 VGND VGND VPWR VPWR net233 sky130_fd_sc_hd__clkbuf_1
Xoutput196 net196 VGND VGND VPWR VPWR dmem_wdata_o[7] sky130_fd_sc_hd__clkbuf_4
X_5279_ clknet_leaf_37_clk_i _0278_ VGND VGND VPWR VPWR i_exec_stage.data_fwd_o\[13\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_97_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_65_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_609 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_17_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2980_ _0890_ _0891_ VGND VGND VPWR VPWR _0892_ sky130_fd_sc_hd__nor2_2
XFILLER_0_83_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4650_ _2252_ VGND VGND VPWR VPWR _0215_ sky130_fd_sc_hd__clkbuf_1
Xinput21 dmem_rdata_i[28] VGND VGND VPWR VPWR net21 sky130_fd_sc_hd__clkbuf_1
Xinput10 dmem_rdata_i[18] VGND VGND VPWR VPWR net10 sky130_fd_sc_hd__clkbuf_1
X_3601_ _0975_ _1492_ VGND VGND VPWR VPWR _1493_ sky130_fd_sc_hd__xnor2_1
Xinput54 imem_rdata_i[28] VGND VGND VPWR VPWR net54 sky130_fd_sc_hd__clkbuf_1
Xinput32 dmem_rdata_i[9] VGND VGND VPWR VPWR net32 sky130_fd_sc_hd__clkbuf_1
Xinput43 imem_rdata_i[18] VGND VGND VPWR VPWR net43 sky130_fd_sc_hd__clkbuf_4
X_4581_ _2218_ VGND VGND VPWR VPWR _0180_ sky130_fd_sc_hd__clkbuf_1
Xinput65 imem_rdata_i[9] VGND VGND VPWR VPWR net65 sky130_fd_sc_hd__clkbuf_1
Xinput98 rf_rs1_i[9] VGND VGND VPWR VPWR net98 sky130_fd_sc_hd__clkbuf_1
Xinput76 rf_rs1_i[18] VGND VGND VPWR VPWR net76 sky130_fd_sc_hd__clkbuf_1
Xinput87 rf_rs1_i[28] VGND VGND VPWR VPWR net87 sky130_fd_sc_hd__clkbuf_1
X_3532_ _0834_ _1409_ _0832_ VGND VGND VPWR VPWR _1427_ sky130_fd_sc_hd__a21o_1
XFILLER_0_12_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3463_ _0448_ _1350_ _1354_ _1355_ _1361_ VGND VGND VPWR VPWR _1362_ sky130_fd_sc_hd__a221o_1
X_2414_ net277 i_decode_stage.decode_state_o\[121\] VGND VGND VPWR VPWR _0367_ sky130_fd_sc_hd__or2b_1
X_5202_ clknet_leaf_32_clk_i _0201_ net287 VGND VGND VPWR VPWR net200 sky130_fd_sc_hd__dfrtp_2
X_3394_ _0666_ _0677_ _0465_ VGND VGND VPWR VPWR _1295_ sky130_fd_sc_hd__mux2_1
X_5133_ clknet_leaf_12_clk_i i_exec_stage.exec_state_o\[8\] net293 VGND VGND VPWR
+ VPWR i_mem_slice_stage.mem_state_o\[40\] sky130_fd_sc_hd__dfrtp_1
X_2345_ i_decode_stage.decode_state_o\[126\] net277 VGND VGND VPWR VPWR _2335_ sky130_fd_sc_hd__xor2_4
X_5064_ clknet_leaf_35_clk_i i_decode_stage.decode_state_o\[40\] net284 VGND VGND
+ VPWR VPWR i_exec_stage.exec_state_o\[39\] sky130_fd_sc_hd__dfrtp_1
X_4015_ net20 _1829_ _1837_ VGND VGND VPWR VPWR i_mem_slice_stage.pre_data\[27\] sky130_fd_sc_hd__a21o_1
X_4917_ clknet_leaf_30_clk_i _0097_ net285 VGND VGND VPWR VPWR net231 sky130_fd_sc_hd__dfrtp_4
XFILLER_0_7_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4848_ clknet_leaf_25_clk_i _0028_ net289 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[32\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_47_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_7_485 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_15_263 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4779_ i_exec_stage.data_fwd_o\[20\] net141 _1839_ VGND VGND VPWR VPWR _2312_ sky130_fd_sc_hd__mux2_1
XFILLER_0_30_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_97_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_93_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_80_144 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_53_369 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_21_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_255 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_61_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_406 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_417 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_428 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_439 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2963_ _0666_ _0875_ VGND VGND VPWR VPWR _0876_ sky130_fd_sc_hd__xnor2_4
X_4702_ _2273_ VGND VGND VPWR VPWR _0246_ sky130_fd_sc_hd__clkbuf_1
X_2894_ _0808_ VGND VGND VPWR VPWR _0809_ sky130_fd_sc_hd__buf_2
X_4633_ i_decode_stage.fetch_state_i\[6\] _2061_ _2234_ VGND VGND VPWR VPWR _2244_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_4_433 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4564_ i_decode_stage.reg_meta_o\[53\] net98 _2207_ VGND VGND VPWR VPWR _2210_ sky130_fd_sc_hd__mux2_1
XFILLER_0_71_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_233 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_4_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3515_ _0834_ _1409_ _0411_ VGND VGND VPWR VPWR _1411_ sky130_fd_sc_hd__o21a_1
XFILLER_0_52_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_69_74 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4495_ _2174_ VGND VGND VPWR VPWR _0138_ sky130_fd_sc_hd__clkbuf_1
Xclkbuf_leaf_11_clk_i clknet_2_2__leaf_clk_i VGND VGND VPWR VPWR clknet_leaf_11_clk_i
+ sky130_fd_sc_hd__clkbuf_16
X_3446_ _0920_ _1343_ _1158_ VGND VGND VPWR VPWR _1345_ sky130_fd_sc_hd__a21oi_1
X_3377_ _0660_ _1138_ _1088_ VGND VGND VPWR VPWR _1279_ sky130_fd_sc_hd__a21o_1
XTAP_962 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_951 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_940 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_40_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5116_ clknet_leaf_14_clk_i i_mem_slice_stage.pre_data\[19\] net294 VGND VGND VPWR
+ VPWR i_mem_slice_stage.mem_state_o\[19\] sky130_fd_sc_hd__dfrtp_1
XTAP_995 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_984 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_973 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_26_clk_i clknet_2_1__leaf_clk_i VGND VGND VPWR VPWR clknet_leaf_26_clk_i
+ sky130_fd_sc_hd__clkbuf_16
X_5047_ clknet_leaf_12_clk_i net137 net293 VGND VGND VPWR VPWR i_exec_stage.exec_state_o\[22\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_79_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_47_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_90_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_50_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_339 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_85_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_38_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_53_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_14_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_155 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_81_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_30_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3300_ _0448_ _0712_ VGND VGND VPWR VPWR _1204_ sky130_fd_sc_hd__nor2_2
XFILLER_0_1_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_33 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_214 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4280_ net61 _2019_ VGND VGND VPWR VPWR _2020_ sky130_fd_sc_hd__nor2_1
X_3231_ _1134_ _1136_ _0660_ VGND VGND VPWR VPWR _1137_ sky130_fd_sc_hd__mux2_1
XTAP_225 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_236 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_247 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_77 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3162_ i_decode_stage.decode_state_o\[236\] _0418_ i_decode_stage.decode_state_o\[238\]
+ VGND VGND VPWR VPWR _1074_ sky130_fd_sc_hd__and3_2
XTAP_269 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_258 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3093_ _0753_ VGND VGND VPWR VPWR _1005_ sky130_fd_sc_hd__inv_2
XFILLER_0_49_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_9_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_71_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3995_ net2 _1807_ _1813_ _1819_ _1834_ VGND VGND VPWR VPWR i_mem_slice_stage.pre_data\[10\]
+ sky130_fd_sc_hd__a221o_1
XFILLER_0_29_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2946_ _2336_ _2341_ net269 VGND VGND VPWR VPWR _0861_ sky130_fd_sc_hd__and3_1
X_2877_ _2336_ _2341_ net256 VGND VGND VPWR VPWR _0792_ sky130_fd_sc_hd__and3_1
X_4616_ _2236_ VGND VGND VPWR VPWR _0197_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_25_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4547_ i_decode_stage.reg_meta_o\[45\] net78 _2179_ VGND VGND VPWR VPWR _2201_ sky130_fd_sc_hd__mux2_1
X_4478_ i_decode_stage.reg_meta_o\[11\] net126 _2012_ VGND VGND VPWR VPWR _2166_ sky130_fd_sc_hd__mux2_1
X_3429_ _0662_ _1328_ VGND VGND VPWR VPWR _1329_ sky130_fd_sc_hd__or2_1
XTAP_770 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_781 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_792 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_225 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_67_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_431 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_90_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_101_293 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_25_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_58_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3780_ _1587_ _1662_ _0523_ VGND VGND VPWR VPWR _1663_ sky130_fd_sc_hd__mux2_1
X_2800_ _0434_ _0711_ _0718_ VGND VGND VPWR VPWR _0719_ sky130_fd_sc_hd__or3_1
X_2731_ i_exec_stage.data_fwd_o\[11\] _0352_ _0355_ _0357_ VGND VGND VPWR VPWR _0654_
+ sky130_fd_sc_hd__or4_1
XFILLER_0_26_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2662_ i_decode_stage.decode_state_o\[236\] _0418_ VGND VGND VPWR VPWR _0592_ sky130_fd_sc_hd__and2_2
X_4401_ net213 _2105_ _2109_ _1927_ VGND VGND VPWR VPWR _2110_ sky130_fd_sc_hd__a211oi_1
XFILLER_0_10_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2593_ _0346_ i_decode_stage.decode_state_o\[133\] VGND VGND VPWR VPWR _0531_ sky130_fd_sc_hd__or2b_1
X_4332_ _2055_ _2056_ VGND VGND VPWR VPWR _2057_ sky130_fd_sc_hd__nor2_1
X_4263_ _2010_ VGND VGND VPWR VPWR _0070_ sky130_fd_sc_hd__clkbuf_1
X_3214_ _0662_ _0546_ _1115_ _1119_ VGND VGND VPWR VPWR _1120_ sky130_fd_sc_hd__a31o_1
X_4194_ _1975_ VGND VGND VPWR VPWR _0036_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_66_97 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3145_ _0465_ _0512_ VGND VGND VPWR VPWR _1057_ sky130_fd_sc_hd__and2_1
X_3076_ _2333_ _0986_ _0987_ VGND VGND VPWR VPWR _0988_ sky130_fd_sc_hd__a21o_1
XFILLER_0_82_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3978_ net13 _1815_ _1823_ _1810_ VGND VGND VPWR VPWR _1824_ sky130_fd_sc_hd__a22o_1
XFILLER_0_17_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2929_ _2336_ _2341_ net248 VGND VGND VPWR VPWR _0844_ sky130_fd_sc_hd__and3_1
XFILLER_0_13_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_309 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_99_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_36_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_51_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xinput8 dmem_rdata_i[16] VGND VGND VPWR VPWR net8 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_78_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4950_ clknet_leaf_1_clk_i _0130_ net283 VGND VGND VPWR VPWR i_decode_stage.reg_meta_o\[11\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_52_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3901_ _1775_ VGND VGND VPWR VPWR net197 sky130_fd_sc_hd__inv_2
XFILLER_0_74_504 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4881_ clknet_leaf_20_clk_i _0061_ net296 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[65\]
+ sky130_fd_sc_hd__dfrtp_1
X_3832_ _1016_ _1710_ VGND VGND VPWR VPWR _1712_ sky130_fd_sc_hd__or2_1
XFILLER_0_52_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3763_ _0707_ _1645_ _1646_ VGND VGND VPWR VPWR _1647_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_54_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2714_ _0358_ _0635_ _0636_ _0637_ VGND VGND VPWR VPWR _0638_ sky130_fd_sc_hd__o31a_1
XFILLER_0_42_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3694_ _0817_ _1581_ _0430_ VGND VGND VPWR VPWR _1582_ sky130_fd_sc_hd__a21oi_1
X_2645_ _0324_ _0326_ net267 VGND VGND VPWR VPWR _0576_ sky130_fd_sc_hd__or3_1
X_2576_ i_mem_slice_stage.mem_state_o\[41\] i_mem_slice_stage.mem_state_o\[2\] i_mem_slice_stage.mem_state_o\[36\]
+ VGND VGND VPWR VPWR _0516_ sky130_fd_sc_hd__mux2_2
X_4315_ net222 _1840_ VGND VGND VPWR VPWR _2043_ sky130_fd_sc_hd__nand2_1
XFILLER_0_77_85 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_10_386 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5295_ clknet_leaf_8_clk_i _0294_ VGND VGND VPWR VPWR i_exec_stage.data_fwd_o\[29\]
+ sky130_fd_sc_hd__dfxtp_1
X_4246_ i_decode_stage.decode_state_o\[66\] i_decode_stage.fetch_state_i\[58\] _1982_
+ VGND VGND VPWR VPWR _2002_ sky130_fd_sc_hd__mux2_1
X_4177_ _1966_ VGND VGND VPWR VPWR _0028_ sky130_fd_sc_hd__clkbuf_1
X_3128_ _0582_ _0712_ VGND VGND VPWR VPWR _1040_ sky130_fd_sc_hd__or2_1
XTAP_1029 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1018 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1007 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3059_ _2333_ _0969_ _0970_ VGND VGND VPWR VPWR _0971_ sky130_fd_sc_hd__a21o_1
XFILLER_0_92_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_60_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_68_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_83_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_24_401 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_24_456 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_24_489 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2430_ _0347_ _0381_ VGND VGND VPWR VPWR _0382_ sky130_fd_sc_hd__nand2_2
XFILLER_0_11_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2361_ i_decode_stage.decode_state_o\[127\] i_exec_stage.data_fwd_o\[36\] VGND VGND
+ VPWR VPWR _0315_ sky130_fd_sc_hd__or2b_1
X_5080_ clknet_leaf_43_clk_i net412 net280 VGND VGND VPWR VPWR i_exec_stage.exec_state_o\[55\]
+ sky130_fd_sc_hd__dfrtp_1
X_4100_ _0519_ _0701_ _1867_ VGND VGND VPWR VPWR _1918_ sky130_fd_sc_hd__o21bai_1
X_4031_ _0620_ _0969_ VGND VGND VPWR VPWR _1849_ sky130_fd_sc_hd__nor2_1
XFILLER_0_2_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_59_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4933_ clknet_leaf_28_clk_i _0113_ net290 VGND VGND VPWR VPWR net217 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_59_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_59_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4864_ clknet_leaf_35_clk_i _0044_ net287 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[48\]
+ sky130_fd_sc_hd__dfrtp_1
XANTENNA_13 i_decode_stage.decode_state_o\[134\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_35 net144 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_46 net160 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_24 net49 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_57 _0489_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4795_ i_exec_stage.data_fwd_o\[28\] net149 _1838_ VGND VGND VPWR VPWR _2320_ sky130_fd_sc_hd__mux2_1
X_3815_ _0709_ _1398_ _1695_ _0754_ VGND VGND VPWR VPWR _1696_ sky130_fd_sc_hd__a22o_1
XANTENNA_68 net39 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_79 net143 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3746_ _0424_ _1630_ VGND VGND VPWR VPWR _1631_ sky130_fd_sc_hd__nand2_1
X_3677_ _0990_ _1564_ _0981_ VGND VGND VPWR VPWR _1565_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_70_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2628_ i_exec_stage.data_fwd_o\[26\] _0560_ _0460_ VGND VGND VPWR VPWR _0561_ sky130_fd_sc_hd__mux2_2
Xoutput142 net142 VGND VGND VPWR VPWR dmem_addr_o[20] sky130_fd_sc_hd__clkbuf_4
X_2559_ _0465_ _0500_ VGND VGND VPWR VPWR _0501_ sky130_fd_sc_hd__and2_1
Xoutput186 net186 VGND VGND VPWR VPWR dmem_wdata_o[27] sky130_fd_sc_hd__clkbuf_4
Xoutput175 net175 VGND VGND VPWR VPWR dmem_wdata_o[17] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_10_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5347_ net40 VGND VGND VPWR VPWR net232 sky130_fd_sc_hd__clkbuf_1
Xoutput153 net153 VGND VGND VPWR VPWR dmem_addr_o[30] sky130_fd_sc_hd__buf_2
Xoutput164 net164 VGND VGND VPWR VPWR dmem_be_o[2] sky130_fd_sc_hd__clkbuf_4
Xoutput197 net197 VGND VGND VPWR VPWR dmem_wdata_o[8] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_10_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5278_ clknet_leaf_0_clk_i _0277_ VGND VGND VPWR VPWR i_exec_stage.data_fwd_o\[12\]
+ sky130_fd_sc_hd__dfxtp_1
X_4229_ _1993_ VGND VGND VPWR VPWR _0053_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_77_150 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_65_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_92_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_0_309 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_33_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput11 dmem_rdata_i[19] VGND VGND VPWR VPWR net11 sky130_fd_sc_hd__clkbuf_1
Xinput22 dmem_rdata_i[29] VGND VGND VPWR VPWR net22 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_24_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4580_ i_decode_stage.reg_meta_o\[61\] net75 _2207_ VGND VGND VPWR VPWR _2218_ sky130_fd_sc_hd__mux2_1
X_3600_ _1488_ _1491_ VGND VGND VPWR VPWR _1492_ sky130_fd_sc_hd__nor2_2
XFILLER_0_71_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput55 imem_rdata_i[29] VGND VGND VPWR VPWR net55 sky130_fd_sc_hd__clkbuf_1
Xinput44 imem_rdata_i[19] VGND VGND VPWR VPWR net44 sky130_fd_sc_hd__clkbuf_4
Xinput33 imem_gnt_i VGND VGND VPWR VPWR net33 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_24_253 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3531_ _1404_ _1406_ _1426_ VGND VGND VPWR VPWR net134 sky130_fd_sc_hd__a21o_2
Xinput88 rf_rs1_i[29] VGND VGND VPWR VPWR net88 sky130_fd_sc_hd__clkbuf_1
Xinput77 rf_rs1_i[19] VGND VGND VPWR VPWR net77 sky130_fd_sc_hd__clkbuf_1
Xinput66 imem_rvalid_i VGND VGND VPWR VPWR net66 sky130_fd_sc_hd__clkbuf_2
Xinput99 rf_rs2_i[0] VGND VGND VPWR VPWR net99 sky130_fd_sc_hd__clkbuf_1
X_3462_ _0448_ _1360_ VGND VGND VPWR VPWR _1361_ sky130_fd_sc_hd__nor2_1
X_2413_ net275 i_decode_stage.decode_state_o\[119\] VGND VGND VPWR VPWR _0366_ sky130_fd_sc_hd__or2b_1
X_5201_ clknet_leaf_38_clk_i net339 net287 VGND VGND VPWR VPWR i_fwd_unit.mem_stage_i\[0\]
+ sky130_fd_sc_hd__dfrtp_1
X_3393_ _0876_ _1293_ VGND VGND VPWR VPWR _1294_ sky130_fd_sc_hd__xnor2_1
X_5132_ clknet_leaf_13_clk_i i_exec_stage.exec_state_o\[7\] net293 VGND VGND VPWR
+ VPWR i_mem_slice_stage.mem_state_o\[39\] sky130_fd_sc_hd__dfrtp_1
X_2344_ i_decode_stage.decode_state_o\[124\] net275 VGND VGND VPWR VPWR _2334_ sky130_fd_sc_hd__xor2_4
X_5063_ clknet_leaf_13_clk_i net154 net294 VGND VGND VPWR VPWR i_exec_stage.exec_state_o\[38\]
+ sky130_fd_sc_hd__dfrtp_1
X_4014_ net19 _1829_ _1837_ VGND VGND VPWR VPWR i_mem_slice_stage.pre_data\[26\] sky130_fd_sc_hd__a21o_1
XFILLER_0_94_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_59_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_85 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4916_ clknet_leaf_30_clk_i _0096_ net285 VGND VGND VPWR VPWR net230 sky130_fd_sc_hd__dfrtp_2
XFILLER_0_47_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4847_ clknet_leaf_24_clk_i _0027_ net287 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[31\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_47_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_15_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_7_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4778_ _2311_ VGND VGND VPWR VPWR _0284_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_15_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3729_ _1566_ _1613_ _1614_ VGND VGND VPWR VPWR _1615_ sky130_fd_sc_hd__a21o_1
XFILLER_0_97_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_93_473 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_80_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_0_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_21_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_267 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_21_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_407 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_418 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_429 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_440 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_56_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2962_ _2333_ net196 _0874_ VGND VGND VPWR VPWR _0875_ sky130_fd_sc_hd__a21oi_4
X_4701_ net204 i_decode_stage.fetch_state_i\[45\] _1927_ VGND VGND VPWR VPWR _2273_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_60_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4632_ _2243_ VGND VGND VPWR VPWR _0206_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_56_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2893_ _0806_ _0807_ VGND VGND VPWR VPWR _0808_ sky130_fd_sc_hd__or2b_1
XFILLER_0_60_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_4_401 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_71_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4563_ _2209_ VGND VGND VPWR VPWR _0171_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_4_445 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_12_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_489 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4494_ i_decode_stage.reg_meta_o\[19\] net103 _2012_ VGND VGND VPWR VPWR _2174_ sky130_fd_sc_hd__mux2_1
X_3514_ _0834_ _1409_ VGND VGND VPWR VPWR _1410_ sky130_fd_sc_hd__nand2_1
X_3445_ _0920_ _1343_ VGND VGND VPWR VPWR _1344_ sky130_fd_sc_hd__or2_1
XFILLER_0_69_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_85_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_952 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_941 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_930 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3376_ _0590_ _1277_ _1274_ _0594_ VGND VGND VPWR VPWR _1278_ sky130_fd_sc_hd__o211a_1
X_5115_ clknet_leaf_14_clk_i i_mem_slice_stage.pre_data\[18\] net294 VGND VGND VPWR
+ VPWR i_mem_slice_stage.mem_state_o\[18\] sky130_fd_sc_hd__dfrtp_1
XTAP_996 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_985 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_974 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_963 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_33_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5046_ clknet_leaf_10_clk_i net136 net292 VGND VGND VPWR VPWR i_exec_stage.exec_state_o\[21\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_39_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_94_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_90_421 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_35_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_62_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_62_178 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_85_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_26_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xcore_298 VGND VGND VPWR VPWR core_298/HI dmem_addr_o[0] sky130_fd_sc_hd__conb_1
XFILLER_0_81_432 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_30_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_204 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_215 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3230_ _0540_ _1078_ _1135_ VGND VGND VPWR VPWR _1136_ sky130_fd_sc_hd__a21oi_1
XTAP_226 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_237 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_248 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_89 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3161_ _1060_ _1072_ _0582_ VGND VGND VPWR VPWR _1073_ sky130_fd_sc_hd__mux2_1
XTAP_259 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_44 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3092_ _0765_ _0783_ _0825_ _1003_ VGND VGND VPWR VPWR _1004_ sky130_fd_sc_hd__or4bb_2
X_3994_ net32 _1807_ _1813_ _1817_ _1834_ VGND VGND VPWR VPWR i_mem_slice_stage.pre_data\[9\]
+ sky130_fd_sc_hd__a221o_1
X_2945_ _0859_ VGND VGND VPWR VPWR _0860_ sky130_fd_sc_hd__inv_2
X_2876_ _0789_ _0790_ VGND VGND VPWR VPWR _0791_ sky130_fd_sc_hd__and2b_1
X_4615_ i_decode_stage.decode_state_o\[121\] net42 _2234_ VGND VGND VPWR VPWR _2236_
+ sky130_fd_sc_hd__mux2_1
X_4546_ _2200_ VGND VGND VPWR VPWR _0163_ sky130_fd_sc_hd__clkbuf_1
X_4477_ _2165_ VGND VGND VPWR VPWR _0129_ sky130_fd_sc_hd__clkbuf_1
X_3428_ _1283_ _1327_ _0422_ VGND VGND VPWR VPWR _1328_ sky130_fd_sc_hd__mux2_1
XTAP_760 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3359_ _0899_ _1234_ _0881_ VGND VGND VPWR VPWR _1261_ sky130_fd_sc_hd__o21a_1
XTAP_771 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_782 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_793 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5029_ clknet_leaf_22_clk_i i_decode_stage.decode_state_o\[5\] net288 VGND VGND VPWR
+ VPWR i_exec_stage.exec_state_o\[4\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_67_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_48_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_63_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_31_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_58_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_10_clk_i clknet_2_2__leaf_clk_i VGND VGND VPWR VPWR clknet_leaf_10_clk_i
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_41_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2730_ _0376_ _0377_ _0378_ i_decode_stage.reg_meta_o\[54\] VGND VGND VPWR VPWR _0653_
+ sky130_fd_sc_hd__o31a_1
X_2661_ _0588_ _0524_ _0590_ VGND VGND VPWR VPWR _0591_ sky130_fd_sc_hd__mux2_1
XFILLER_0_14_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_leaf_25_clk_i clknet_2_1__leaf_clk_i VGND VGND VPWR VPWR clknet_leaf_25_clk_i
+ sky130_fd_sc_hd__clkbuf_16
X_4400_ net213 _2105_ VGND VGND VPWR VPWR _2109_ sky130_fd_sc_hd__nor2_1
X_2592_ i_exec_stage.data_fwd_o\[30\] _0529_ _0460_ VGND VGND VPWR VPWR _0530_ sky130_fd_sc_hd__mux2_1
X_4331_ net227 _2051_ VGND VGND VPWR VPWR _2056_ sky130_fd_sc_hd__nor2_1
X_4262_ net39 i_decode_stage.decode_state_o\[118\] _1967_ VGND VGND VPWR VPWR _2010_
+ sky130_fd_sc_hd__mux2_1
X_3213_ _0662_ _1118_ VGND VGND VPWR VPWR _1119_ sky130_fd_sc_hd__nor2_1
XFILLER_0_5_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4193_ i_decode_stage.decode_state_o\[40\] i_decode_stage.fetch_state_i\[0\] _1840_
+ VGND VGND VPWR VPWR _1975_ sky130_fd_sc_hd__mux2_1
X_3144_ _0344_ _0507_ _1055_ VGND VGND VPWR VPWR _1056_ sky130_fd_sc_hd__a21oi_1
X_3075_ i_decode_stage.decode_state_o\[58\] _0731_ _0733_ VGND VGND VPWR VPWR _0987_
+ sky130_fd_sc_hd__a21oi_1
XFILLER_0_15_91 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_9_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3977_ net4 net21 i_exec_stage.exec_state_o\[8\] VGND VGND VPWR VPWR _1823_ sky130_fd_sc_hd__mux2_1
XFILLER_0_57_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2928_ _0841_ _0842_ VGND VGND VPWR VPWR _0843_ sky130_fd_sc_hd__nand2b_2
XFILLER_0_32_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2859_ _2336_ _2341_ net258 VGND VGND VPWR VPWR _0774_ sky130_fd_sc_hd__and3_1
X_4529_ i_decode_stage.reg_meta_o\[36\] net122 _2179_ VGND VGND VPWR VPWR _2192_ sky130_fd_sc_hd__mux2_1
XTAP_590 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_63_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput9 dmem_rdata_i[17] VGND VGND VPWR VPWR net9 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_59_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_86_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_86_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4880_ clknet_leaf_19_clk_i _0060_ net296 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[64\]
+ sky130_fd_sc_hd__dfrtp_1
X_3900_ _0336_ _0908_ _1774_ VGND VGND VPWR VPWR _1775_ sky130_fd_sc_hd__mux2_1
X_3831_ _1016_ _1710_ VGND VGND VPWR VPWR _1711_ sky130_fd_sc_hd__nand2_1
XFILLER_0_27_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_52_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3762_ _0590_ _1498_ _0712_ VGND VGND VPWR VPWR _1646_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_39_281 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2713_ i_exec_stage.data_fwd_o\[13\] _0352_ _0355_ _0357_ VGND VGND VPWR VPWR _0637_
+ sky130_fd_sc_hd__or4_1
X_3693_ _0958_ _0993_ _1001_ VGND VGND VPWR VPWR _1581_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_2_510 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2644_ i_mem_slice_stage.mem_state_o\[74\] _0328_ _0575_ _0330_ VGND VGND VPWR VPWR
+ net267 sky130_fd_sc_hd__a22o_1
X_2575_ _2336_ _2341_ i_decode_stage.reg_meta_o\[8\] VGND VGND VPWR VPWR _0515_ sky130_fd_sc_hd__a21o_1
XFILLER_0_77_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4314_ _1926_ _1924_ VGND VGND VPWR VPWR _2042_ sky130_fd_sc_hd__nor2_8
XFILLER_0_77_97 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5294_ clknet_leaf_8_clk_i _0293_ VGND VGND VPWR VPWR i_exec_stage.data_fwd_o\[28\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_10_398 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4245_ _2001_ VGND VGND VPWR VPWR _0061_ sky130_fd_sc_hd__clkbuf_1
X_4176_ i_decode_stage.fetch_state_i\[24\] i_decode_stage.decode_state_o\[32\] _1936_
+ VGND VGND VPWR VPWR _1966_ sky130_fd_sc_hd__mux2_1
X_3127_ i_decode_stage.decode_state_o\[236\] i_decode_stage.decode_state_o\[237\]
+ _1037_ _1038_ VGND VGND VPWR VPWR _1039_ sky130_fd_sc_hd__a31o_1
XTAP_1019 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1008 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3058_ i_decode_stage.decode_state_o\[56\] _0731_ _0733_ VGND VGND VPWR VPWR _0970_
+ sky130_fd_sc_hd__a21oi_1
XFILLER_0_65_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_421 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_9_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_402 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_95_151 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_83_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_83_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_83_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_24_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_24_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2360_ i_decode_stage.decode_state_o\[125\] i_exec_stage.data_fwd_o\[34\] VGND VGND
+ VPWR VPWR _0314_ sky130_fd_sc_hd__or2b_1
X_4030_ _0475_ _0803_ _0812_ _0498_ VGND VGND VPWR VPWR _1848_ sky130_fd_sc_hd__a22o_1
X_4932_ clknet_leaf_26_clk_i _0112_ net289 VGND VGND VPWR VPWR net216 sky130_fd_sc_hd__dfrtp_4
XFILLER_0_47_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_74_346 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XANTENNA_14 i_decode_stage.fetch_state_i\[16\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4863_ clknet_leaf_29_clk_i _0043_ net291 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[47\]
+ sky130_fd_sc_hd__dfrtp_1
XANTENNA_47 net194 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_15_402 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XANTENNA_25 net49 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_36 net146 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_62_508 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4794_ _2319_ VGND VGND VPWR VPWR _0292_ sky130_fd_sc_hd__clkbuf_1
X_3814_ _0415_ _1693_ _1694_ VGND VGND VPWR VPWR _1695_ sky130_fd_sc_hd__o21ai_1
XANTENNA_69 net39 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_15_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_58 _0516_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_12_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_27_284 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3745_ _0417_ _0464_ _0789_ _0413_ _1629_ VGND VGND VPWR VPWR _1630_ sky130_fd_sc_hd__o221a_1
XFILLER_0_30_405 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_88_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_42_276 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3676_ _0989_ _1526_ _0982_ VGND VGND VPWR VPWR _1564_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_88_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2627_ net259 i_decode_stage.reg_meta_o\[69\] _0457_ VGND VGND VPWR VPWR _0560_ sky130_fd_sc_hd__mux2_1
Xoutput132 net132 VGND VGND VPWR VPWR dmem_addr_o[10] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_63_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput143 net143 VGND VGND VPWR VPWR dmem_addr_o[21] sky130_fd_sc_hd__clkbuf_4
Xoutput176 net176 VGND VGND VPWR VPWR dmem_wdata_o[18] sky130_fd_sc_hd__clkbuf_4
X_2558_ _0451_ _0498_ _0462_ _0499_ VGND VGND VPWR VPWR _0500_ sky130_fd_sc_hd__a2bb2o_4
Xoutput165 net165 VGND VGND VPWR VPWR dmem_be_o[3] sky130_fd_sc_hd__clkbuf_4
Xoutput154 net154 VGND VGND VPWR VPWR dmem_addr_o[31] sky130_fd_sc_hd__clkbuf_4
Xoutput187 net187 VGND VGND VPWR VPWR dmem_wdata_o[28] sky130_fd_sc_hd__clkbuf_4
Xoutput198 net198 VGND VGND VPWR VPWR dmem_wdata_o[9] sky130_fd_sc_hd__clkbuf_4
X_5277_ clknet_leaf_37_clk_i _0276_ VGND VGND VPWR VPWR i_exec_stage.data_fwd_o\[11\]
+ sky130_fd_sc_hd__dfxtp_1
X_2489_ _0435_ _0436_ _0437_ _0438_ VGND VGND VPWR VPWR _0439_ sky130_fd_sc_hd__and4_4
X_4228_ i_decode_stage.decode_state_o\[57\] i_decode_stage.fetch_state_i\[49\] _1982_
+ VGND VGND VPWR VPWR _1993_ sky130_fd_sc_hd__mux2_1
XFILLER_0_97_405 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4159_ _1957_ VGND VGND VPWR VPWR _0019_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_97_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_77_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_80_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_21_405 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_21_427 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_21_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_29_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_68_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput12 dmem_rdata_i[1] VGND VGND VPWR VPWR net12 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_83_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_71_349 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xinput23 dmem_rdata_i[2] VGND VGND VPWR VPWR net23 sky130_fd_sc_hd__clkbuf_1
X_3530_ _1410_ _1411_ _1425_ VGND VGND VPWR VPWR _1426_ sky130_fd_sc_hd__a21o_1
Xinput34 imem_rdata_i[0] VGND VGND VPWR VPWR net34 sky130_fd_sc_hd__clkbuf_1
Xinput45 imem_rdata_i[1] VGND VGND VPWR VPWR net45 sky130_fd_sc_hd__clkbuf_1
Xinput56 imem_rdata_i[2] VGND VGND VPWR VPWR net56 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_12_405 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xinput78 rf_rs1_i[1] VGND VGND VPWR VPWR net78 sky130_fd_sc_hd__clkbuf_1
Xinput67 rf_rs1_i[0] VGND VGND VPWR VPWR net67 sky130_fd_sc_hd__clkbuf_1
Xinput89 rf_rs1_i[2] VGND VGND VPWR VPWR net89 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_24_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3461_ _0661_ _1088_ _0524_ _1287_ _1359_ VGND VGND VPWR VPWR _1360_ sky130_fd_sc_hd__o221a_1
X_5200_ clknet_leaf_38_clk_i net401 net131 VGND VGND VPWR VPWR net279 sky130_fd_sc_hd__dfrtp_4
X_2412_ i_decode_stage.decode_state_o\[119\] net275 VGND VGND VPWR VPWR _0365_ sky130_fd_sc_hd__or2b_1
X_3392_ _1270_ _1264_ _1267_ VGND VGND VPWR VPWR _1293_ sky130_fd_sc_hd__a21o_1
X_5131_ clknet_leaf_36_clk_i net354 net287 VGND VGND VPWR VPWR i_fwd_unit.mem_stage_i\[39\]
+ sky130_fd_sc_hd__dfrtp_1
X_2343_ _2332_ VGND VGND VPWR VPWR _2333_ sky130_fd_sc_hd__buf_12
X_5062_ clknet_leaf_14_clk_i net153 net295 VGND VGND VPWR VPWR i_exec_stage.exec_state_o\[37\]
+ sky130_fd_sc_hd__dfrtp_1
X_4013_ net18 _1829_ _1837_ VGND VGND VPWR VPWR i_mem_slice_stage.pre_data\[25\] sky130_fd_sc_hd__a21o_1
XFILLER_0_79_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_28_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_79_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_74_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_59_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_90_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4915_ clknet_leaf_38_clk_i _0095_ net282 VGND VGND VPWR VPWR net229 sky130_fd_sc_hd__dfrtp_4
X_4846_ clknet_leaf_24_clk_i _0026_ net290 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[30\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_62_316 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4777_ i_exec_stage.data_fwd_o\[19\] net140 _1839_ VGND VGND VPWR VPWR _2311_ sky130_fd_sc_hd__mux2_1
X_3728_ _0806_ _0815_ _0807_ VGND VGND VPWR VPWR _1614_ sky130_fd_sc_hd__o21a_1
X_3659_ _0983_ _0998_ _1530_ VGND VGND VPWR VPWR _1548_ sky130_fd_sc_hd__or3_1
XFILLER_0_30_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_100_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_3_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_97_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_78_460 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_93_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_53_305 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_93_485 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_61_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_61_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_408 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_419 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_29_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2961_ i_decode_stage.decode_state_o\[47\] _0731_ _0751_ i_decode_stage.decode_state_o\[131\]
+ VGND VGND VPWR VPWR _0874_ sky130_fd_sc_hd__a22o_1
XFILLER_0_84_452 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4700_ _2272_ VGND VGND VPWR VPWR _0245_ sky130_fd_sc_hd__clkbuf_1
X_4631_ i_decode_stage.fetch_state_i\[5\] _2057_ _2234_ VGND VGND VPWR VPWR _2243_
+ sky130_fd_sc_hd__mux2_1
X_2892_ _0478_ _0805_ VGND VGND VPWR VPWR _0807_ sky130_fd_sc_hd__nand2_1
XFILLER_0_71_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_113 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_4_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4562_ i_decode_stage.reg_meta_o\[52\] net97 _2207_ VGND VGND VPWR VPWR _2209_ sky130_fd_sc_hd__mux2_1
XFILLER_0_4_457 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_40_500 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_100_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4493_ _2173_ VGND VGND VPWR VPWR _0137_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_52_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3513_ _0928_ _0935_ _1340_ _1364_ _1408_ VGND VGND VPWR VPWR _1409_ sky130_fd_sc_hd__a41o_1
X_3444_ _0913_ _1340_ _0911_ VGND VGND VPWR VPWR _1343_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_85_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_953 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_942 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_931 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_920 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3375_ _0662_ _1115_ VGND VGND VPWR VPWR _1277_ sky130_fd_sc_hd__nor2_1
X_5114_ clknet_leaf_14_clk_i i_mem_slice_stage.pre_data\[17\] net294 VGND VGND VPWR
+ VPWR i_mem_slice_stage.mem_state_o\[17\] sky130_fd_sc_hd__dfrtp_1
XTAP_986 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_975 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_964 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_997 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5045_ clknet_leaf_8_clk_i net135 net292 VGND VGND VPWR VPWR i_exec_stage.exec_state_o\[20\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_79_202 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_26_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_79_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_94_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_94_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_433 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4829_ clknet_leaf_42_clk_i _0009_ net280 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[13\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_90_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_43_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_101_421 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xcore_299 VGND VGND VPWR VPWR core_299/HI dmem_addr_o[1] sky130_fd_sc_hd__conb_1
XFILLER_0_66_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_53_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_1_405 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_1_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_205 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_227 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_216 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_238 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3160_ _1066_ _1071_ _0523_ VGND VGND VPWR VPWR _1072_ sky130_fd_sc_hd__mux2_1
XTAP_249 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold1 i_exec_stage.exec_state_o\[40\] VGND VGND VPWR VPWR net338 sky130_fd_sc_hd__clkdlybuf4s25_1
X_3091_ _0958_ _0993_ _1002_ VGND VGND VPWR VPWR _1003_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_9_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3993_ net31 _1829_ _1813_ _1811_ _1834_ VGND VGND VPWR VPWR i_mem_slice_stage.pre_data\[8\]
+ sky130_fd_sc_hd__a221o_1
XFILLER_0_29_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2944_ _0834_ _0843_ _0852_ _0858_ VGND VGND VPWR VPWR _0859_ sky130_fd_sc_hd__nand4b_1
XFILLER_0_44_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2875_ _0464_ _0788_ VGND VGND VPWR VPWR _0790_ sky130_fd_sc_hd__nand2_1
XFILLER_0_13_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4614_ _2235_ VGND VGND VPWR VPWR _0196_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_32_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4545_ i_decode_stage.reg_meta_o\[44\] net67 _2179_ VGND VGND VPWR VPWR _2200_ sky130_fd_sc_hd__mux2_1
XFILLER_0_25_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_393 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4476_ i_decode_stage.reg_meta_o\[10\] net125 _2012_ VGND VGND VPWR VPWR _2165_ sky130_fd_sc_hd__mux2_1
XFILLER_0_96_85 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3427_ _0345_ _0672_ _1089_ VGND VGND VPWR VPWR _1327_ sky130_fd_sc_hd__a21oi_1
XTAP_750 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_761 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3358_ _1260_ VGND VGND VPWR VPWR net157 sky130_fd_sc_hd__buf_2
XTAP_772 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_783 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_794 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3289_ _0660_ _1193_ VGND VGND VPWR VPWR _1194_ sky130_fd_sc_hd__nand2_1
X_5028_ clknet_leaf_16_clk_i i_decode_stage.decode_state_o\[118\] net295 VGND VGND
+ VPWR VPWR i_exec_stage.exec_state_o\[2\] sky130_fd_sc_hd__dfrtp_2
XFILLER_0_95_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_leaf_6_clk_i clknet_2_2__leaf_clk_i VGND VGND VPWR VPWR clknet_leaf_6_clk_i
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_98_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_508 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_81_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2660_ _0589_ VGND VGND VPWR VPWR _0590_ sky130_fd_sc_hd__buf_8
XFILLER_0_54_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2591_ net263 i_decode_stage.reg_meta_o\[73\] _0457_ VGND VGND VPWR VPWR _0529_ sky130_fd_sc_hd__mux2_1
X_4330_ net222 net225 net226 net227 VGND VGND VPWR VPWR _2055_ sky130_fd_sc_hd__and4_1
XFILLER_0_1_268 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4261_ _2009_ VGND VGND VPWR VPWR _0069_ sky130_fd_sc_hd__clkbuf_1
X_3212_ _1117_ VGND VGND VPWR VPWR _1118_ sky130_fd_sc_hd__inv_2
X_4192_ _1974_ VGND VGND VPWR VPWR _0035_ sky130_fd_sc_hd__clkbuf_1
X_3143_ _0465_ _0495_ VGND VGND VPWR VPWR _1055_ sky130_fd_sc_hd__and2_1
X_3074_ i_exec_stage.data_fwd_o\[19\] _0726_ _0985_ VGND VGND VPWR VPWR _0986_ sky130_fd_sc_hd__o21ai_4
XFILLER_0_49_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3976_ net26 _1809_ _1822_ VGND VGND VPWR VPWR i_mem_slice_stage.pre_data\[3\] sky130_fd_sc_hd__a21o_1
XFILLER_0_17_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2927_ _0603_ _0840_ VGND VGND VPWR VPWR _0842_ sky130_fd_sc_hd__nand2_2
XFILLER_0_93_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_17_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_17_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2858_ _0771_ _0772_ VGND VGND VPWR VPWR _0773_ sky130_fd_sc_hd__nand2b_2
X_2789_ _0662_ _0685_ _0706_ _0707_ VGND VGND VPWR VPWR _0708_ sky130_fd_sc_hd__a211o_1
X_4528_ _2191_ VGND VGND VPWR VPWR _0154_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_1_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4459_ _2156_ VGND VGND VPWR VPWR _0120_ sky130_fd_sc_hd__clkbuf_1
XTAP_580 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_591 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_51_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_51_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_52_57 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_39_260 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3830_ _1637_ _1708_ _1709_ _0754_ VGND VGND VPWR VPWR _1710_ sky130_fd_sc_hd__a2bb2o_1
X_3761_ _1570_ _1644_ _0660_ VGND VGND VPWR VPWR _1645_ sky130_fd_sc_hd__mux2_1
XFILLER_0_39_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2712_ _0376_ _0377_ _0378_ i_decode_stage.reg_meta_o\[56\] VGND VGND VPWR VPWR _0636_
+ sky130_fd_sc_hd__o31a_1
XFILLER_0_14_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3692_ _1573_ _1574_ _1576_ _1579_ VGND VGND VPWR VPWR _1580_ sky130_fd_sc_hd__a211o_1
X_2643_ i_mem_slice_stage.mem_state_o\[42\] i_mem_slice_stage.mem_state_o\[3\] i_mem_slice_stage.mem_state_o\[36\]
+ VGND VGND VPWR VPWR _0575_ sky130_fd_sc_hd__mux2_1
X_2574_ _0502_ _0513_ _0421_ VGND VGND VPWR VPWR _0514_ sky130_fd_sc_hd__mux2_1
X_4313_ i_decode_stage.decode_state_o\[243\] _1929_ _1940_ VGND VGND VPWR VPWR _0089_
+ sky130_fd_sc_hd__a21o_1
X_5293_ clknet_leaf_8_clk_i _0292_ VGND VGND VPWR VPWR i_exec_stage.data_fwd_o\[27\]
+ sky130_fd_sc_hd__dfxtp_1
X_4244_ i_decode_stage.decode_state_o\[65\] i_decode_stage.fetch_state_i\[57\] _1982_
+ VGND VGND VPWR VPWR _2001_ sky130_fd_sc_hd__mux2_1
X_4175_ _1965_ VGND VGND VPWR VPWR _0027_ sky130_fd_sc_hd__clkbuf_1
X_3126_ i_decode_stage.decode_state_o\[236\] i_decode_stage.decode_state_o\[237\]
+ _1033_ VGND VGND VPWR VPWR _1038_ sky130_fd_sc_hd__and3b_1
XTAP_1009 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3057_ i_exec_stage.data_fwd_o\[17\] _0726_ _0968_ VGND VGND VPWR VPWR _0969_ sky130_fd_sc_hd__o21ai_4
XFILLER_0_92_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_433 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3959_ i_exec_stage.exec_state_o\[1\] i_exec_stage.exec_state_o\[8\] _1805_ _1808_
+ VGND VGND VPWR VPWR _1809_ sky130_fd_sc_hd__o31ai_4
XFILLER_0_18_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_33_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_33_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_393 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xclkbuf_leaf_24_clk_i clknet_2_1__leaf_clk_i VGND VGND VPWR VPWR clknet_leaf_24_clk_i
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_95_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_39_clk_i clknet_2_0__leaf_clk_i VGND VGND VPWR VPWR clknet_leaf_39_clk_i
+ sky130_fd_sc_hd__clkbuf_16
XPHY_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_91_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_491 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_47_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_86_141 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4931_ clknet_leaf_28_clk_i _0111_ net290 VGND VGND VPWR VPWR net215 sky130_fd_sc_hd__dfrtp_2
X_4862_ clknet_leaf_38_clk_i _0042_ net282 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[46\]
+ sky130_fd_sc_hd__dfrtp_2
XFILLER_0_59_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_86_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3813_ _0417_ _0551_ _0755_ _0419_ _0424_ VGND VGND VPWR VPWR _1694_ sky130_fd_sc_hd__o221a_1
XANTENNA_48 net200 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_37 net152 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_15 i_exec_stage.exec_state_o\[5\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_26 net50 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4793_ i_exec_stage.data_fwd_o\[27\] net148 _1838_ VGND VGND VPWR VPWR _2319_ sky130_fd_sc_hd__mux2_1
XFILLER_0_15_414 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XANTENNA_59 _0516_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_12_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_27_296 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3744_ _1198_ _0789_ VGND VGND VPWR VPWR _1629_ sky130_fd_sc_hd__nand2_1
X_3675_ _0983_ _0991_ _1525_ VGND VGND VPWR VPWR _1563_ sky130_fd_sc_hd__or3_1
XFILLER_0_30_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_30_428 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_42_288 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2626_ i_mem_slice_stage.mem_state_o\[96\] _0452_ _0559_ _0455_ VGND VGND VPWR VPWR
+ net259 sky130_fd_sc_hd__a22o_1
XFILLER_0_2_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput133 net133 VGND VGND VPWR VPWR dmem_addr_o[11] sky130_fd_sc_hd__buf_2
Xoutput177 net177 VGND VGND VPWR VPWR dmem_wdata_o[19] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_10_141 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xoutput166 net166 VGND VGND VPWR VPWR dmem_req_o sky130_fd_sc_hd__buf_2
X_2557_ _0346_ i_decode_stage.decode_state_o\[124\] VGND VGND VPWR VPWR _0499_ sky130_fd_sc_hd__or2b_1
Xoutput155 net155 VGND VGND VPWR VPWR dmem_addr_o[3] sky130_fd_sc_hd__buf_2
Xoutput144 net144 VGND VGND VPWR VPWR dmem_addr_o[22] sky130_fd_sc_hd__clkbuf_4
Xoutput188 net188 VGND VGND VPWR VPWR dmem_wdata_o[29] sky130_fd_sc_hd__clkbuf_4
X_5276_ clknet_leaf_38_clk_i _0275_ VGND VGND VPWR VPWR i_exec_stage.data_fwd_o\[10\]
+ sky130_fd_sc_hd__dfxtp_1
X_2488_ i_decode_stage.reg_meta_o\[43\] _0313_ _0317_ _0318_ VGND VGND VPWR VPWR _0438_
+ sky130_fd_sc_hd__and4_1
Xoutput199 net199 VGND VGND VPWR VPWR dmem_we_o sky130_fd_sc_hd__clkbuf_4
X_4227_ _1992_ VGND VGND VPWR VPWR _0052_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_97_417 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4158_ i_decode_stage.fetch_state_i\[15\] i_decode_stage.decode_state_o\[23\] _1936_
+ VGND VGND VPWR VPWR _1957_ sky130_fd_sc_hd__mux2_1
XFILLER_0_69_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3109_ i_decode_stage.decode_state_o\[70\] _0731_ VGND VGND VPWR VPWR _1021_ sky130_fd_sc_hd__nand2_1
X_4089_ _1900_ _1906_ VGND VGND VPWR VPWR _1907_ sky130_fd_sc_hd__or2b_1
XFILLER_0_38_506 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_92_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_33_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_5_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_21_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput13 dmem_rdata_i[20] VGND VGND VPWR VPWR net13 sky130_fd_sc_hd__clkbuf_1
Xinput24 dmem_rdata_i[30] VGND VGND VPWR VPWR net24 sky130_fd_sc_hd__clkbuf_1
Xinput46 imem_rdata_i[20] VGND VGND VPWR VPWR net46 sky130_fd_sc_hd__clkbuf_4
Xinput35 imem_rdata_i[10] VGND VGND VPWR VPWR net35 sky130_fd_sc_hd__clkbuf_1
Xinput57 imem_rdata_i[30] VGND VGND VPWR VPWR net57 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_0_12_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput68 rf_rs1_i[10] VGND VGND VPWR VPWR net68 sky130_fd_sc_hd__clkbuf_1
Xinput79 rf_rs1_i[20] VGND VGND VPWR VPWR net79 sky130_fd_sc_hd__clkbuf_1
X_3460_ _0716_ _1326_ _1358_ _1041_ VGND VGND VPWR VPWR _1359_ sky130_fd_sc_hd__o22a_1
X_2411_ net278 i_decode_stage.decode_state_o\[122\] VGND VGND VPWR VPWR _0364_ sky130_fd_sc_hd__or2b_1
X_3391_ _1292_ VGND VGND VPWR VPWR net158 sky130_fd_sc_hd__buf_2
X_5130_ clknet_leaf_4_clk_i i_exec_stage.exec_state_o\[5\] net284 VGND VGND VPWR VPWR
+ i_mem_slice_stage.mem_state_o\[37\] sky130_fd_sc_hd__dfrtp_1
X_2342_ i_decode_stage.decode_state_o\[233\] i_decode_stage.decode_state_o\[232\]
+ VGND VGND VPWR VPWR _2332_ sky130_fd_sc_hd__nor2_2
X_5061_ clknet_leaf_14_clk_i net151 net294 VGND VGND VPWR VPWR i_exec_stage.exec_state_o\[36\]
+ sky130_fd_sc_hd__dfrtp_1
X_4012_ net17 _1829_ _1837_ VGND VGND VPWR VPWR i_mem_slice_stage.pre_data\[24\] sky130_fd_sc_hd__a21o_1
XFILLER_0_87_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4914_ clknet_leaf_38_clk_i _0094_ net282 VGND VGND VPWR VPWR net228 sky130_fd_sc_hd__dfrtp_4
XFILLER_0_47_314 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4845_ clknet_leaf_32_clk_i _0025_ net287 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[29\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_74_144 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4776_ _2310_ VGND VGND VPWR VPWR _0283_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_55_380 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_62_328 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3727_ _0809_ _0817_ VGND VGND VPWR VPWR _1613_ sky130_fd_sc_hd__nor2_1
X_3658_ _0998_ _1530_ _0983_ VGND VGND VPWR VPWR _1547_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_100_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3589_ _1199_ _0850_ VGND VGND VPWR VPWR _1482_ sky130_fd_sc_hd__nand2_1
X_2609_ _0544_ VGND VGND VPWR VPWR _0545_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_11_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_100_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5259_ clknet_leaf_25_clk_i _0258_ net290 VGND VGND VPWR VPWR i_decode_stage.fetch_state_i\[57\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_65_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_93_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_53_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_65_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_80_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_21_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_409 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_203 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_56_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2960_ _0873_ VGND VGND VPWR VPWR net196 sky130_fd_sc_hd__clkinv_2
XFILLER_0_84_464 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2891_ _0478_ _0805_ VGND VGND VPWR VPWR _0806_ sky130_fd_sc_hd__nor2_1
X_4630_ _2242_ VGND VGND VPWR VPWR _0205_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_56_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_71_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_47 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4561_ _2208_ VGND VGND VPWR VPWR _0170_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_40_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_71_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4492_ i_decode_stage.reg_meta_o\[18\] net102 _2012_ VGND VGND VPWR VPWR _2173_ sky130_fd_sc_hd__mux2_1
X_3512_ _0950_ _1407_ VGND VGND VPWR VPWR _1408_ sky130_fd_sc_hd__nand2_1
XFILLER_0_69_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3443_ _1156_ _1319_ _1336_ _1342_ VGND VGND VPWR VPWR net160 sky130_fd_sc_hd__a211o_4
XFILLER_0_100_85 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_910 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5113_ clknet_leaf_14_clk_i i_mem_slice_stage.pre_data\[16\] net294 VGND VGND VPWR
+ VPWR i_mem_slice_stage.mem_state_o\[16\] sky130_fd_sc_hd__dfrtp_1
XTAP_943 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_932 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_921 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3374_ _0584_ _1275_ VGND VGND VPWR VPWR _1276_ sky130_fd_sc_hd__nor2_1
XFILLER_0_85_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_987 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_976 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_965 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_954 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_998 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5044_ clknet_leaf_10_clk_i net134 net292 VGND VGND VPWR VPWR i_exec_stage.exec_state_o\[19\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_79_225 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_79_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4828_ clknet_leaf_42_clk_i _0008_ net280 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[12\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_35_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_90_445 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_90_489 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4759_ i_exec_stage.data_fwd_o\[10\] net161 _1839_ VGND VGND VPWR VPWR _2302_ sky130_fd_sc_hd__mux2_1
XFILLER_0_50_90 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_101_433 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_101_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_98_501 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_85_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_38_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_19_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_30_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_1_417 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_61_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_206 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_217 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_228 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_239 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold2 i_exec_stage.valid_o VGND VGND VPWR VPWR net339 sky130_fd_sc_hd__clkdlybuf4s25_1
X_3090_ _0824_ _1001_ VGND VGND VPWR VPWR _1002_ sky130_fd_sc_hd__nor2_1
X_3992_ i_exec_stage.exec_state_o\[2\] _1832_ VGND VGND VPWR VPWR _1834_ sky130_fd_sc_hd__nor2_4
XFILLER_0_29_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2943_ _0608_ _0857_ VGND VGND VPWR VPWR _0858_ sky130_fd_sc_hd__xnor2_4
X_2874_ _0464_ _0788_ VGND VGND VPWR VPWR _0789_ sky130_fd_sc_hd__nor2_1
X_4613_ i_decode_stage.decode_state_o\[120\] net41 _2234_ VGND VGND VPWR VPWR _2235_
+ sky130_fd_sc_hd__mux2_1
X_4544_ i_decode_stage.reg_meta_o\[43\] _1928_ _1932_ _2199_ VGND VGND VPWR VPWR _0162_
+ sky130_fd_sc_hd__a22o_1
X_4475_ _2164_ VGND VGND VPWR VPWR _0128_ sky130_fd_sc_hd__clkbuf_1
X_3426_ _1325_ VGND VGND VPWR VPWR _1326_ sky130_fd_sc_hd__buf_2
XFILLER_0_0_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_740 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_751 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3357_ _1232_ _1236_ _1249_ _1259_ VGND VGND VPWR VPWR _1260_ sky130_fd_sc_hd__or4_1
XFILLER_0_29_91 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_762 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_773 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_784 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_795 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5027_ clknet_leaf_16_clk_i i_decode_stage.decode_state_o\[117\] net295 VGND VGND
+ VPWR VPWR i_exec_stage.exec_state_o\[1\] sky130_fd_sc_hd__dfrtp_4
X_3288_ _0422_ _0714_ _1192_ VGND VGND VPWR VPWR _1193_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_48_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_90_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_31_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_8_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_14_309 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2590_ i_mem_slice_stage.mem_state_o\[100\] _0452_ _0528_ _0455_ VGND VGND VPWR VPWR
+ net263 sky130_fd_sc_hd__a22o_1
X_4260_ net38 _0601_ _1967_ VGND VGND VPWR VPWR _2009_ sky130_fd_sc_hd__mux2_1
X_3211_ _0394_ _1064_ _1116_ VGND VGND VPWR VPWR _1117_ sky130_fd_sc_hd__o21a_1
X_4191_ i_decode_stage.fetch_state_i\[31\] i_decode_stage.decode_state_o\[39\] _1967_
+ VGND VGND VPWR VPWR _1974_ sky130_fd_sc_hd__mux2_1
XFILLER_0_66_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3142_ _1051_ _1053_ _0421_ VGND VGND VPWR VPWR _1054_ sky130_fd_sc_hd__mux2_1
X_3073_ i_decode_stage.reg_meta_o\[24\] _0727_ _0386_ _0984_ VGND VGND VPWR VPWR _0985_
+ sky130_fd_sc_hd__a211o_1
XFILLER_0_82_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3975_ net11 _1815_ _1821_ _1810_ VGND VGND VPWR VPWR _1822_ sky130_fd_sc_hd__a22o_1
X_2926_ _0603_ _0840_ VGND VGND VPWR VPWR _0841_ sky130_fd_sc_hd__nor2_2
XFILLER_0_17_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2857_ _0563_ _0770_ VGND VGND VPWR VPWR _0772_ sky130_fd_sc_hd__nand2_1
XFILLER_0_72_253 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_86_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_31_92 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_32_106 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_72_286 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2788_ _0582_ VGND VGND VPWR VPWR _0707_ sky130_fd_sc_hd__buf_8
X_4527_ i_decode_stage.reg_meta_o\[35\] net120 _2179_ VGND VGND VPWR VPWR _2191_ sky130_fd_sc_hd__mux2_1
X_4458_ net63 i_decode_stage.decode_state_o\[147\] _1967_ VGND VGND VPWR VPWR _2156_
+ sky130_fd_sc_hd__mux2_1
X_3409_ _0901_ _1261_ _0876_ VGND VGND VPWR VPWR _1310_ sky130_fd_sc_hd__o21ai_1
X_4389_ net140 _2042_ _2045_ _2099_ _2100_ VGND VGND VPWR VPWR _0106_ sky130_fd_sc_hd__a221o_1
XTAP_570 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_581 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_592 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_323 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_95_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_95_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_98_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_98_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3760_ _0540_ _1602_ _1643_ VGND VGND VPWR VPWR _1644_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_6_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_39_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2711_ _0363_ _0369_ _0374_ net245 VGND VGND VPWR VPWR _0635_ sky130_fd_sc_hd__and4_1
XFILLER_0_54_253 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_27_489 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3691_ _1199_ _1577_ _1578_ _0816_ VGND VGND VPWR VPWR _1579_ sky130_fd_sc_hd__o31a_1
XFILLER_0_2_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2642_ _2336_ _2341_ i_decode_stage.reg_meta_o\[9\] VGND VGND VPWR VPWR _0574_ sky130_fd_sc_hd__a21o_1
X_2573_ _0507_ _0512_ _0343_ VGND VGND VPWR VPWR _0513_ sky130_fd_sc_hd__mux2_1
XFILLER_0_77_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4312_ i_decode_stage.decode_state_o\[242\] _1928_ _2041_ net39 VGND VGND VPWR VPWR
+ _0088_ sky130_fd_sc_hd__a22o_1
X_5292_ clknet_leaf_8_clk_i _0291_ VGND VGND VPWR VPWR i_exec_stage.data_fwd_o\[26\]
+ sky130_fd_sc_hd__dfxtp_1
X_4243_ _2000_ VGND VGND VPWR VPWR _0060_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_58_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4174_ i_decode_stage.fetch_state_i\[23\] i_decode_stage.decode_state_o\[31\] _1936_
+ VGND VGND VPWR VPWR _1965_ sky130_fd_sc_hd__mux2_1
X_3125_ _1035_ _1025_ _0746_ _1034_ VGND VGND VPWR VPWR _1037_ sky130_fd_sc_hd__o31a_1
Xclkbuf_leaf_5_clk_i clknet_2_0__leaf_clk_i VGND VGND VPWR VPWR clknet_leaf_5_clk_i
+ sky130_fd_sc_hd__clkbuf_16
X_3056_ i_decode_stage.reg_meta_o\[22\] _0727_ _0386_ _0967_ VGND VGND VPWR VPWR _0968_
+ sky130_fd_sc_hd__a211o_1
XFILLER_0_77_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_77_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_18_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_445 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3958_ _1807_ VGND VGND VPWR VPWR _1808_ sky130_fd_sc_hd__inv_2
X_3889_ _1129_ _1476_ _1765_ VGND VGND VPWR VPWR _1766_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_18_489 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_45_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2909_ _0818_ _0819_ _0822_ _0800_ _0823_ VGND VGND VPWR VPWR _0824_ sky130_fd_sc_hd__a221o_1
XFILLER_0_5_361 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_60_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_83_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_36_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_51_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_32_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_32_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_57 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4930_ clknet_leaf_25_clk_i _0110_ net290 VGND VGND VPWR VPWR net214 sky130_fd_sc_hd__dfrtp_2
XFILLER_0_86_153 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4861_ clknet_leaf_39_clk_i _0041_ net282 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[45\]
+ sky130_fd_sc_hd__dfrtp_1
X_3812_ _0755_ VGND VGND VPWR VPWR _1693_ sky130_fd_sc_hd__inv_2
XFILLER_0_74_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_16 imem_rdata_i[3] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_27 net50 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4792_ _2318_ VGND VGND VPWR VPWR _0291_ sky130_fd_sc_hd__clkbuf_1
XANTENNA_38 net153 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3743_ _1412_ _1475_ _1627_ _1281_ _1315_ VGND VGND VPWR VPWR _1628_ sky130_fd_sc_hd__a221o_1
XFILLER_0_82_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_426 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XANTENNA_49 net201 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3674_ _1156_ _1547_ _1548_ _1562_ VGND VGND VPWR VPWR net141 sky130_fd_sc_hd__a31o_4
X_2625_ i_mem_slice_stage.mem_state_o\[64\] i_mem_slice_stage.mem_state_o\[25\] _0453_
+ VGND VGND VPWR VPWR _0559_ sky130_fd_sc_hd__mux2_1
Xoutput134 net134 VGND VGND VPWR VPWR dmem_addr_o[12] sky130_fd_sc_hd__buf_2
Xoutput167 net167 VGND VGND VPWR VPWR dmem_wdata_o[0] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_10_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2556_ i_exec_stage.data_fwd_o\[21\] _0497_ _0460_ VGND VGND VPWR VPWR _0498_ sky130_fd_sc_hd__mux2_2
Xoutput156 net156 VGND VGND VPWR VPWR dmem_addr_o[4] sky130_fd_sc_hd__clkbuf_4
Xoutput145 net145 VGND VGND VPWR VPWR dmem_addr_o[23] sky130_fd_sc_hd__clkbuf_4
Xoutput189 net189 VGND VGND VPWR VPWR dmem_wdata_o[2] sky130_fd_sc_hd__clkbuf_4
Xoutput178 net178 VGND VGND VPWR VPWR dmem_wdata_o[1] sky130_fd_sc_hd__buf_2
X_5275_ clknet_leaf_41_clk_i _0274_ VGND VGND VPWR VPWR i_exec_stage.data_fwd_o\[9\]
+ sky130_fd_sc_hd__dfxtp_1
X_2487_ _0308_ _0310_ _0314_ _0315_ VGND VGND VPWR VPWR _0437_ sky130_fd_sc_hd__and4_1
XFILLER_0_10_197 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4226_ i_decode_stage.decode_state_o\[56\] i_decode_stage.fetch_state_i\[48\] _1982_
+ VGND VGND VPWR VPWR _1992_ sky130_fd_sc_hd__mux2_1
X_4157_ _1956_ VGND VGND VPWR VPWR _0018_ sky130_fd_sc_hd__clkbuf_1
X_3108_ i_exec_stage.data_fwd_o\[31\] _0726_ _1019_ VGND VGND VPWR VPWR _1020_ sky130_fd_sc_hd__o21ai_4
XFILLER_0_97_429 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4088_ _1898_ _1893_ _1905_ _1899_ _1897_ VGND VGND VPWR VPWR _1906_ sky130_fd_sc_hd__a221o_1
X_3039_ _0949_ _0927_ VGND VGND VPWR VPWR _0951_ sky130_fd_sc_hd__or2_1
XFILLER_0_65_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_33_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_88_429 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_56_326 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_71_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput25 dmem_rdata_i[31] VGND VGND VPWR VPWR net25 sky130_fd_sc_hd__clkbuf_1
Xinput14 dmem_rdata_i[21] VGND VGND VPWR VPWR net14 sky130_fd_sc_hd__clkbuf_1
Xinput36 imem_rdata_i[11] VGND VGND VPWR VPWR net36 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_24_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_64_392 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xinput58 imem_rdata_i[31] VGND VGND VPWR VPWR net58 sky130_fd_sc_hd__clkbuf_1
Xinput47 imem_rdata_i[21] VGND VGND VPWR VPWR net47 sky130_fd_sc_hd__clkbuf_4
Xinput69 rf_rs1_i[11] VGND VGND VPWR VPWR net69 sky130_fd_sc_hd__clkbuf_1
X_2410_ _0362_ VGND VGND VPWR VPWR _0363_ sky130_fd_sc_hd__buf_2
X_3390_ _1263_ _1266_ _1271_ _1291_ VGND VGND VPWR VPWR _1292_ sky130_fd_sc_hd__or4_1
X_5060_ clknet_leaf_15_clk_i net150 net293 VGND VGND VPWR VPWR i_exec_stage.exec_state_o\[35\]
+ sky130_fd_sc_hd__dfrtp_1
X_4011_ net16 _1829_ _1837_ VGND VGND VPWR VPWR i_mem_slice_stage.pre_data\[23\] sky130_fd_sc_hd__a21o_1
XFILLER_0_79_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_90_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_59_131 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_87_473 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4913_ clknet_leaf_39_clk_i _0093_ net282 VGND VGND VPWR VPWR net227 sky130_fd_sc_hd__dfrtp_2
XFILLER_0_47_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4844_ clknet_leaf_32_clk_i _0024_ net287 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[28\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_62_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4775_ i_exec_stage.data_fwd_o\[18\] net139 _1839_ VGND VGND VPWR VPWR _2310_ sky130_fd_sc_hd__mux2_1
X_3726_ _1607_ _1610_ _1611_ VGND VGND VPWR VPWR _1612_ sky130_fd_sc_hd__or3_1
Xclkbuf_leaf_23_clk_i clknet_2_1__leaf_clk_i VGND VGND VPWR VPWR clknet_leaf_23_clk_i
+ sky130_fd_sc_hd__clkbuf_16
X_3657_ _0411_ _1528_ _1532_ _1546_ VGND VGND VPWR VPWR net140 sky130_fd_sc_hd__a211o_4
XFILLER_0_100_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3588_ _1477_ _1478_ _1479_ _1480_ _0709_ VGND VGND VPWR VPWR _1481_ sky130_fd_sc_hd__a32o_1
X_2608_ i_decode_stage.decode_state_o\[100\] _0543_ _0347_ VGND VGND VPWR VPWR _0544_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_11_473 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2539_ _0482_ _0346_ _0462_ VGND VGND VPWR VPWR _0483_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_100_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_leaf_38_clk_i clknet_2_0__leaf_clk_i VGND VGND VPWR VPWR clknet_leaf_38_clk_i
+ sky130_fd_sc_hd__clkbuf_16
X_5258_ clknet_leaf_26_clk_i _0257_ net289 VGND VGND VPWR VPWR i_decode_stage.fetch_state_i\[56\]
+ sky130_fd_sc_hd__dfrtp_1
X_4209_ _1983_ VGND VGND VPWR VPWR _0043_ sky130_fd_sc_hd__clkbuf_1
X_5189_ clknet_leaf_28_clk_i net392 net290 VGND VGND VPWR VPWR i_mem_slice_stage.mem_state_o\[96\]
+ sky130_fd_sc_hd__dfrtp_2
XFILLER_0_61_351 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_88_215 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_96_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2890_ _2333_ _0803_ _0804_ VGND VGND VPWR VPWR _0805_ sky130_fd_sc_hd__a21o_1
X_4560_ i_decode_stage.reg_meta_o\[51\] net96 _2207_ VGND VGND VPWR VPWR _2208_ sky130_fd_sc_hd__mux2_1
XFILLER_0_71_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_71_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4491_ _2172_ VGND VGND VPWR VPWR _0136_ sky130_fd_sc_hd__clkbuf_1
X_3511_ _1379_ _1365_ _1382_ _0951_ VGND VGND VPWR VPWR _1407_ sky130_fd_sc_hd__o211ai_1
X_3442_ _0913_ _1340_ _1341_ VGND VGND VPWR VPWR _1342_ sky130_fd_sc_hd__o21a_1
XFILLER_0_100_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3373_ _0707_ _1272_ _1274_ VGND VGND VPWR VPWR _1275_ sky130_fd_sc_hd__a21bo_1
XTAP_900 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5112_ clknet_leaf_14_clk_i i_mem_slice_stage.pre_data\[15\] net294 VGND VGND VPWR
+ VPWR i_mem_slice_stage.mem_state_o\[15\] sky130_fd_sc_hd__dfrtp_1
XTAP_944 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_933 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_922 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_911 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_977 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_966 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_955 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_999 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_988 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5043_ clknet_leaf_15_clk_i net133 net295 VGND VGND VPWR VPWR i_exec_stage.exec_state_o\[18\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_18_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_87_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_75_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_75_476 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4827_ clknet_leaf_43_clk_i _0007_ net280 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[11\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_47_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_90_457 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4758_ _2301_ VGND VGND VPWR VPWR _0274_ sky130_fd_sc_hd__clkbuf_1
X_4689_ net229 i_decode_stage.fetch_state_i\[39\] _1967_ VGND VGND VPWR VPWR _2267_
+ sky130_fd_sc_hd__mux2_1
X_3709_ _0809_ _1595_ _0430_ VGND VGND VPWR VPWR _1596_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_101_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_101_489 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_11_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_11_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_53_126 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_1_429 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_207 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_218 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_229 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold3 i_exec_stage.exec_state_o\[38\] VGND VGND VPWR VPWR net340 sky130_fd_sc_hd__clkdlybuf4s25_1
X_3991_ net30 _1829_ _1813_ _1830_ _1833_ VGND VGND VPWR VPWR i_mem_slice_stage.pre_data\[7\]
+ sky130_fd_sc_hd__a221o_1
XFILLER_0_76_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2942_ _2333_ _0855_ _0856_ VGND VGND VPWR VPWR _0857_ sky130_fd_sc_hd__a21o_2
XFILLER_0_71_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2873_ _2333_ _0786_ _0787_ VGND VGND VPWR VPWR _0788_ sky130_fd_sc_hd__a21o_1
X_4612_ _0722_ VGND VGND VPWR VPWR _2234_ sky130_fd_sc_hd__buf_12
X_4543_ net62 net60 _1928_ VGND VGND VPWR VPWR _2199_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_20_72 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4474_ i_decode_stage.reg_meta_o\[9\] net124 _2012_ VGND VGND VPWR VPWR _2164_ sky130_fd_sc_hd__mux2_1
XFILLER_0_40_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3425_ _0589_ _0712_ VGND VGND VPWR VPWR _1325_ sky130_fd_sc_hd__or2_1
XFILLER_0_0_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3356_ _1254_ _1258_ _0448_ VGND VGND VPWR VPWR _1259_ sky130_fd_sc_hd__o21a_1
XTAP_730 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_741 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_752 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3287_ _0540_ _1191_ VGND VGND VPWR VPWR _1192_ sky130_fd_sc_hd__or2_1
XTAP_763 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_774 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_785 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5026_ clknet_leaf_13_clk_i i_decode_stage.decode_state_o\[0\] net293 VGND VGND VPWR
+ VPWR i_exec_stage.exec_state_o\[0\] sky130_fd_sc_hd__dfrtp_1
XTAP_796 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_45_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_48_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_90_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_16_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_31_354 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_101_253 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_98_376 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_39_454 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_26_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_54_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_81_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3210_ _0394_ _1068_ VGND VGND VPWR VPWR _1116_ sky130_fd_sc_hd__nand2_1
X_4190_ _1973_ VGND VGND VPWR VPWR _0034_ sky130_fd_sc_hd__clkbuf_1
X_3141_ _0345_ _0500_ _1052_ VGND VGND VPWR VPWR _1053_ sky130_fd_sc_hd__a21oi_1
X_3072_ _2336_ _2341_ net251 VGND VGND VPWR VPWR _0984_ sky130_fd_sc_hd__and3_1
XFILLER_0_77_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3974_ net3 net20 i_exec_stage.exec_state_o\[8\] VGND VGND VPWR VPWR _1821_ sky130_fd_sc_hd__mux2_1
X_2925_ _2333_ _0838_ _0839_ VGND VGND VPWR VPWR _0840_ sky130_fd_sc_hd__a21o_1
X_2856_ _0563_ _0770_ VGND VGND VPWR VPWR _0771_ sky130_fd_sc_hd__nor2_1
XFILLER_0_72_265 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_32_118 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_72_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2787_ _0540_ _0696_ _0705_ VGND VGND VPWR VPWR _0706_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_79_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_53_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4526_ _2190_ VGND VGND VPWR VPWR _0153_ sky130_fd_sc_hd__clkbuf_1
X_4457_ net154 _2042_ _2155_ VGND VGND VPWR VPWR _0119_ sky130_fd_sc_hd__a21o_1
XFILLER_0_0_281 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3408_ _1129_ _1304_ _1307_ _1308_ VGND VGND VPWR VPWR _1309_ sky130_fd_sc_hd__a22o_1
X_4388_ net209 _1927_ VGND VGND VPWR VPWR _2100_ sky130_fd_sc_hd__and2_1
XTAP_560 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3339_ _1041_ _1241_ VGND VGND VPWR VPWR _1242_ sky130_fd_sc_hd__nor2_1
XTAP_571 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_582 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_593 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5009_ clknet_leaf_1_clk_i _0189_ net283 VGND VGND VPWR VPWR i_decode_stage.reg_meta_o\[70\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_95_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_48_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_63_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_51_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_36_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_59_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2710_ i_mem_slice_stage.mem_state_o\[83\] _0328_ _0634_ _0330_ VGND VGND VPWR VPWR
+ net245 sky130_fd_sc_hd__a22o_1
XFILLER_0_14_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_14_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_54_265 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3690_ _0417_ _0500_ _0815_ _1198_ VGND VGND VPWR VPWR _1578_ sky130_fd_sc_hd__a2bb2o_1
X_2641_ _0525_ _0539_ _0546_ _0572_ VGND VGND VPWR VPWR _0573_ sky130_fd_sc_hd__a31o_1
XFILLER_0_42_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2572_ _0451_ _0510_ _0492_ _0511_ VGND VGND VPWR VPWR _0512_ sky130_fd_sc_hd__a2bb2o_4
XFILLER_0_50_460 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_10_313 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_22_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4311_ _2037_ _2041_ _1840_ i_decode_stage.decode_state_o\[241\] VGND VGND VPWR VPWR
+ _0087_ sky130_fd_sc_hd__o2bb2a_1
X_5291_ clknet_leaf_8_clk_i _0290_ VGND VGND VPWR VPWR i_exec_stage.data_fwd_o\[25\]
+ sky130_fd_sc_hd__dfxtp_1
X_4242_ i_decode_stage.decode_state_o\[64\] i_decode_stage.fetch_state_i\[56\] _1982_
+ VGND VGND VPWR VPWR _2000_ sky130_fd_sc_hd__mux2_1
XFILLER_0_93_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4173_ _1964_ VGND VGND VPWR VPWR _0026_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_93_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3124_ _1026_ _1027_ _1035_ VGND VGND VPWR VPWR _1036_ sky130_fd_sc_hd__a21o_1
X_3055_ _2336_ _2341_ net249 VGND VGND VPWR VPWR _0967_ sky130_fd_sc_hd__and3_1
XFILLER_0_26_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_77_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3957_ _1806_ VGND VGND VPWR VPWR _1807_ sky130_fd_sc_hd__buf_2
XFILLER_0_18_457 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_45_254 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2908_ _0464_ _0788_ VGND VGND VPWR VPWR _0823_ sky130_fd_sc_hd__and2b_1
X_3888_ _0707_ _1627_ _1763_ _1764_ _0448_ VGND VGND VPWR VPWR _1765_ sky130_fd_sc_hd__a221o_1
XFILLER_0_45_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_5_373 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2839_ _0551_ _0753_ VGND VGND VPWR VPWR _0754_ sky130_fd_sc_hd__nand2_1
X_4509_ i_decode_stage.reg_meta_o\[26\] net111 _2179_ VGND VGND VPWR VPWR _2182_ sky130_fd_sc_hd__mux2_1
XTAP_390 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_68_379 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_83_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_91_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_51_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_26 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_59_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4860_ clknet_leaf_30_clk_i _0040_ net282 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[44\]
+ sky130_fd_sc_hd__dfrtp_1
X_3811_ _1421_ _1393_ _0709_ VGND VGND VPWR VPWR _1692_ sky130_fd_sc_hd__a21oi_1
XANTENNA_39 net155 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_17 net39 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_27_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_28 net130 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4791_ i_exec_stage.data_fwd_o\[26\] net147 _1838_ VGND VGND VPWR VPWR _2318_ sky130_fd_sc_hd__mux2_1
X_3742_ _1623_ _1626_ _0660_ VGND VGND VPWR VPWR _1627_ sky130_fd_sc_hd__mux2_1
XFILLER_0_82_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_15_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_15_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3673_ _0411_ _1550_ _1551_ _1561_ VGND VGND VPWR VPWR _1562_ sky130_fd_sc_hd__a211o_1
X_2624_ _0343_ _0551_ _0557_ VGND VGND VPWR VPWR _0558_ sky130_fd_sc_hd__a21o_1
XFILLER_0_2_321 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_2_365 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xoutput168 net168 VGND VGND VPWR VPWR dmem_wdata_o[10] sky130_fd_sc_hd__buf_2
X_2555_ net254 i_decode_stage.reg_meta_o\[64\] _0457_ VGND VGND VPWR VPWR _0497_ sky130_fd_sc_hd__mux2_1
Xoutput157 net157 VGND VGND VPWR VPWR dmem_addr_o[5] sky130_fd_sc_hd__clkbuf_4
Xoutput135 net135 VGND VGND VPWR VPWR dmem_addr_o[13] sky130_fd_sc_hd__buf_2
Xoutput146 net146 VGND VGND VPWR VPWR dmem_addr_o[24] sky130_fd_sc_hd__clkbuf_4
Xoutput179 net179 VGND VGND VPWR VPWR dmem_wdata_o[20] sky130_fd_sc_hd__buf_2
X_2486_ _0309_ _0312_ VGND VGND VPWR VPWR _0436_ sky130_fd_sc_hd__and2_1
X_5274_ clknet_leaf_9_clk_i _0273_ VGND VGND VPWR VPWR i_exec_stage.data_fwd_o\[8\]
+ sky130_fd_sc_hd__dfxtp_1
X_4225_ _1991_ VGND VGND VPWR VPWR _0051_ sky130_fd_sc_hd__clkbuf_1
X_4156_ i_decode_stage.fetch_state_i\[14\] i_decode_stage.decode_state_o\[22\] _1936_
+ VGND VGND VPWR VPWR _1956_ sky130_fd_sc_hd__mux2_1
X_3107_ i_decode_stage.reg_meta_o\[36\] _0727_ _0386_ _1018_ VGND VGND VPWR VPWR _1019_
+ sky130_fd_sc_hd__a211o_1
X_4087_ _1894_ VGND VGND VPWR VPWR _1905_ sky130_fd_sc_hd__inv_2
X_3038_ _0949_ _0927_ VGND VGND VPWR VPWR _0950_ sky130_fd_sc_hd__nand2_1
XFILLER_0_77_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4989_ clknet_leaf_0_clk_i _0169_ net281 VGND VGND VPWR VPWR i_decode_stage.reg_meta_o\[50\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_58_390 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_73_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_33_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_68_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_56_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_146 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xinput15 dmem_rdata_i[22] VGND VGND VPWR VPWR net15 sky130_fd_sc_hd__clkbuf_1
Xinput26 dmem_rdata_i[3] VGND VGND VPWR VPWR net26 sky130_fd_sc_hd__clkbuf_1
Xinput37 imem_rdata_i[12] VGND VGND VPWR VPWR net37 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_64_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput48 imem_rdata_i[22] VGND VGND VPWR VPWR net48 sky130_fd_sc_hd__clkbuf_4
Xinput59 imem_rdata_i[3] VGND VGND VPWR VPWR net59 sky130_fd_sc_hd__dlymetal6s2s_1
Xclkbuf_leaf_4_clk_i clknet_2_2__leaf_clk_i VGND VGND VPWR VPWR clknet_leaf_4_clk_i
+ sky130_fd_sc_hd__clkbuf_16
X_4010_ net15 _1829_ _1837_ VGND VGND VPWR VPWR i_mem_slice_stage.pre_data\[22\] sky130_fd_sc_hd__a21o_1
XFILLER_0_74_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4912_ clknet_leaf_39_clk_i _0092_ net282 VGND VGND VPWR VPWR net226 sky130_fd_sc_hd__dfrtp_4
XFILLER_0_59_143 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_87_485 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4843_ clknet_leaf_32_clk_i _0023_ net285 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[27\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_74_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4774_ _2309_ VGND VGND VPWR VPWR _0282_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_43_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3725_ _1275_ _1479_ _1144_ _0799_ VGND VGND VPWR VPWR _1611_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_0_70_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_15_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_30_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3656_ _1533_ _1536_ _1545_ VGND VGND VPWR VPWR _1546_ sky130_fd_sc_hd__or3_1
X_3587_ _1300_ _1312_ _0582_ VGND VGND VPWR VPWR _1480_ sky130_fd_sc_hd__mux2_1
XFILLER_0_11_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2607_ i_exec_stage.data_fwd_o\[32\] _0542_ _0460_ VGND VGND VPWR VPWR _0543_ sky130_fd_sc_hd__mux2_1
XFILLER_0_61_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_11_485 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2538_ i_decode_stage.decode_state_o\[126\] VGND VGND VPWR VPWR _0482_ sky130_fd_sc_hd__inv_2
X_5257_ clknet_leaf_27_clk_i _0256_ net290 VGND VGND VPWR VPWR i_decode_stage.fetch_state_i\[55\]
+ sky130_fd_sc_hd__dfrtp_1
X_2469_ _0418_ i_decode_stage.decode_state_o\[239\] i_decode_stage.decode_state_o\[238\]
+ i_decode_stage.decode_state_o\[236\] VGND VGND VPWR VPWR _0419_ sky130_fd_sc_hd__or4bb_4
X_4208_ i_decode_stage.decode_state_o\[47\] i_decode_stage.fetch_state_i\[39\] _1982_
+ VGND VGND VPWR VPWR _1983_ sky130_fd_sc_hd__mux2_1
X_5188_ clknet_leaf_26_clk_i net384 net289 VGND VGND VPWR VPWR i_mem_slice_stage.mem_state_o\[95\]
+ sky130_fd_sc_hd__dfrtp_1
X_4139_ _1947_ VGND VGND VPWR VPWR _0009_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_78_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_78_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_38_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_38_338 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_80_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_61_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_88_227 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_69_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_84_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_25_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3510_ _0430_ _1405_ VGND VGND VPWR VPWR _1406_ sky130_fd_sc_hd__nor2_1
X_4490_ i_decode_stage.reg_meta_o\[17\] net101 _2012_ VGND VGND VPWR VPWR _2172_ sky130_fd_sc_hd__mux2_1
XFILLER_0_52_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3441_ _0913_ _1340_ _1158_ VGND VGND VPWR VPWR _1341_ sky130_fd_sc_hd__a21oi_1
X_3372_ _0582_ _1273_ VGND VGND VPWR VPWR _1274_ sky130_fd_sc_hd__or2_1
XTAP_901 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5111_ clknet_leaf_13_clk_i i_mem_slice_stage.pre_data\[14\] net293 VGND VGND VPWR
+ VPWR i_mem_slice_stage.mem_state_o\[14\] sky130_fd_sc_hd__dfrtp_1
XTAP_934 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_923 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_912 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_978 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_967 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_956 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_945 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_989 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5042_ clknet_leaf_11_clk_i net132 net292 VGND VGND VPWR VPWR i_exec_stage.exec_state_o\[17\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_94_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_75_455 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_75_488 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4826_ clknet_leaf_41_clk_i _0006_ net280 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[10\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_62_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_90_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4757_ i_exec_stage.data_fwd_o\[9\] net160 _1839_ VGND VGND VPWR VPWR _2301_ sky130_fd_sc_hd__mux2_1
XFILLER_0_31_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4688_ _2266_ VGND VGND VPWR VPWR _0239_ sky130_fd_sc_hd__clkbuf_1
X_3708_ _0817_ _1581_ _0820_ VGND VGND VPWR VPWR _1595_ sky130_fd_sc_hd__a21o_1
X_3639_ _0966_ _1511_ VGND VGND VPWR VPWR _1529_ sky130_fd_sc_hd__nor2_1
XPHY_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_208 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_219 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold4 i_exec_stage.exec_state_o\[39\] VGND VGND VPWR VPWR net341 sky130_fd_sc_hd__clkdlybuf4s25_1
XFILLER_0_89_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_leaf_22_clk_i clknet_2_1__leaf_clk_i VGND VGND VPWR VPWR clknet_leaf_22_clk_i
+ sky130_fd_sc_hd__clkbuf_16
X_3990_ _1832_ VGND VGND VPWR VPWR _1833_ sky130_fd_sc_hd__inv_2
XFILLER_0_57_411 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2941_ i_decode_stage.decode_state_o\[54\] _0339_ _0733_ VGND VGND VPWR VPWR _0856_
+ sky130_fd_sc_hd__a21oi_1
Xclkbuf_leaf_37_clk_i clknet_2_0__leaf_clk_i VGND VGND VPWR VPWR clknet_leaf_37_clk_i
+ sky130_fd_sc_hd__clkbuf_16
X_4611_ _2233_ VGND VGND VPWR VPWR _0195_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_44_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2872_ i_decode_stage.decode_state_o\[63\] _0731_ _0733_ VGND VGND VPWR VPWR _0787_
+ sky130_fd_sc_hd__a21oi_1
XFILLER_0_95_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_458 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_13_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4542_ _2198_ VGND VGND VPWR VPWR _0161_ sky130_fd_sc_hd__clkbuf_1
X_4473_ _2163_ VGND VGND VPWR VPWR _0127_ sky130_fd_sc_hd__clkbuf_1
X_3424_ _1088_ _0584_ _1322_ _1323_ VGND VGND VPWR VPWR _1324_ sky130_fd_sc_hd__a22o_1
X_3355_ _0584_ _1257_ VGND VGND VPWR VPWR _1258_ sky130_fd_sc_hd__nor2_1
XTAP_720 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_731 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_742 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3286_ _0465_ _0691_ _0704_ VGND VGND VPWR VPWR _1191_ sky130_fd_sc_hd__o21ai_1
XTAP_753 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_764 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_775 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_786 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5025_ clknet_leaf_38_clk_i i_decode_stage.decode_state_o\[140\] net131 VGND VGND
+ VPWR VPWR i_exec_stage.reg_meta_o\[4\] sky130_fd_sc_hd__dfrtp_1
XTAP_797 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_67_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_75_241 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_48_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_63_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_63_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4809_ i_exec_stage.data_fwd_o\[35\] i_decode_stage.decode_state_o\[138\] _1838_
+ VGND VGND VPWR VPWR _2327_ sky130_fd_sc_hd__mux2_1
XFILLER_0_90_277 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_43_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_101_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_366 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_101_265 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_98_388 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_39_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_39_466 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_81_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_26_105 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3140_ _0465_ _0478_ VGND VGND VPWR VPWR _1052_ sky130_fd_sc_hd__and2_1
XFILLER_0_89_322 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3071_ _0981_ _0982_ VGND VGND VPWR VPWR _0983_ sky130_fd_sc_hd__nand2b_2
XFILLER_0_89_355 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_10_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_92_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3973_ net23 _1809_ _1820_ VGND VGND VPWR VPWR i_mem_slice_stage.pre_data\[2\] sky130_fd_sc_hd__a21o_1
X_2924_ i_decode_stage.decode_state_o\[53\] _0731_ _0733_ VGND VGND VPWR VPWR _0839_
+ sky130_fd_sc_hd__a21oi_1
XFILLER_0_57_296 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_5_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2855_ _0384_ _0768_ _0769_ _0752_ VGND VGND VPWR VPWR _0770_ sky130_fd_sc_hd__o211a_1
XFILLER_0_31_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_72_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2786_ _0422_ _0697_ _0704_ _0525_ VGND VGND VPWR VPWR _0705_ sky130_fd_sc_hd__a31o_1
XFILLER_0_25_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4525_ i_decode_stage.reg_meta_o\[34\] net119 _2179_ VGND VGND VPWR VPWR _2190_ sky130_fd_sc_hd__mux2_1
XFILLER_0_40_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4456_ net224 _1936_ _2045_ _2154_ VGND VGND VPWR VPWR _2155_ sky130_fd_sc_hd__a22o_1
X_4387_ net209 _2095_ VGND VGND VPWR VPWR _2099_ sky130_fd_sc_hd__xor2_1
X_3407_ _0666_ _0875_ VGND VGND VPWR VPWR _1308_ sky130_fd_sc_hd__nand2_1
X_3338_ _0715_ _1240_ _0523_ VGND VGND VPWR VPWR _1241_ sky130_fd_sc_hd__mux2_1
XFILLER_0_0_293 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_550 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_561 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_572 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_583 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_594 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3269_ _0422_ _0684_ VGND VGND VPWR VPWR _1174_ sky130_fd_sc_hd__or2_1
XFILLER_0_56_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5008_ clknet_leaf_1_clk_i _0188_ net283 VGND VGND VPWR VPWR i_decode_stage.reg_meta_o\[69\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_63_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_16_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_27_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2640_ _0523_ _0571_ VGND VGND VPWR VPWR _0572_ sky130_fd_sc_hd__and2_1
XFILLER_0_54_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2571_ i_decode_stage.decode_state_o\[121\] _0493_ VGND VGND VPWR VPWR _0511_ sky130_fd_sc_hd__nand2_1
XFILLER_0_10_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4310_ i_decode_stage.decode_state_o\[240\] _1928_ _2041_ net37 VGND VGND VPWR VPWR
+ _0086_ sky130_fd_sc_hd__a22o_1
X_5290_ clknet_leaf_10_clk_i _0289_ VGND VGND VPWR VPWR i_exec_stage.data_fwd_o\[24\]
+ sky130_fd_sc_hd__dfxtp_1
X_4241_ _1999_ VGND VGND VPWR VPWR _0059_ sky130_fd_sc_hd__clkbuf_1
X_4172_ i_decode_stage.fetch_state_i\[22\] i_decode_stage.decode_state_o\[30\] _1936_
+ VGND VGND VPWR VPWR _1964_ sky130_fd_sc_hd__mux2_1
X_3123_ _1033_ _1034_ VGND VGND VPWR VPWR _1035_ sky130_fd_sc_hd__nand2_2
X_3054_ _0964_ _0965_ VGND VGND VPWR VPWR _0966_ sky130_fd_sc_hd__nor2_2
XFILLER_0_77_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3956_ i_exec_stage.exec_state_o\[0\] i_exec_stage.exec_state_o\[1\] VGND VGND VPWR
+ VPWR _1806_ sky130_fd_sc_hd__and2b_1
XFILLER_0_18_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2907_ _0809_ _0820_ _0821_ VGND VGND VPWR VPWR _0822_ sky130_fd_sc_hd__a21o_1
X_3887_ _0662_ _1699_ _0707_ VGND VGND VPWR VPWR _1764_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_45_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_33_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2838_ _0384_ _0749_ _0750_ _0752_ VGND VGND VPWR VPWR _0753_ sky130_fd_sc_hd__o211a_1
XFILLER_0_5_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2769_ i_exec_stage.data_fwd_o\[4\] _0352_ _0355_ _0357_ VGND VGND VPWR VPWR _0688_
+ sky130_fd_sc_hd__or4_1
X_4508_ _2181_ VGND VGND VPWR VPWR _0144_ sky130_fd_sc_hd__clkbuf_1
X_4439_ net218 net219 _2125_ net220 VGND VGND VPWR VPWR _2141_ sky130_fd_sc_hd__a31o_1
XTAP_380 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_391 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_47_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_99_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_74_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4790_ _2317_ VGND VGND VPWR VPWR _0290_ sky130_fd_sc_hd__clkbuf_1
X_3810_ _0411_ _1689_ _1690_ VGND VGND VPWR VPWR _1691_ sky130_fd_sc_hd__and3_1
X_3741_ _0422_ _1586_ _1625_ VGND VGND VPWR VPWR _1626_ sky130_fd_sc_hd__o21ai_1
XANTENNA_18 net42 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_29 net133 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_12_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_12_85 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3672_ _1129_ _0594_ _1185_ _1557_ _1560_ VGND VGND VPWR VPWR _1561_ sky130_fd_sc_hd__a311o_1
X_2623_ _0465_ _0556_ VGND VGND VPWR VPWR _0557_ sky130_fd_sc_hd__and2_1
XFILLER_0_88_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_88_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_2_333 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_23_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2554_ i_mem_slice_stage.mem_state_o\[91\] _0452_ _0496_ _0455_ VGND VGND VPWR VPWR
+ net254 sky130_fd_sc_hd__a22o_1
XFILLER_0_2_377 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xoutput158 net158 VGND VGND VPWR VPWR dmem_addr_o[6] sky130_fd_sc_hd__clkbuf_4
Xoutput136 net136 VGND VGND VPWR VPWR dmem_addr_o[14] sky130_fd_sc_hd__buf_2
Xoutput147 net147 VGND VGND VPWR VPWR dmem_addr_o[25] sky130_fd_sc_hd__clkbuf_4
Xoutput169 net169 VGND VGND VPWR VPWR dmem_wdata_o[11] sky130_fd_sc_hd__buf_2
X_5273_ clknet_leaf_0_clk_i _0272_ VGND VGND VPWR VPWR i_exec_stage.data_fwd_o\[7\]
+ sky130_fd_sc_hd__dfxtp_1
X_2485_ i_exec_stage.data_fwd_o\[0\] i_exec_stage.data_fwd_o\[39\] _0307_ VGND VGND
+ VPWR VPWR _0435_ sky130_fd_sc_hd__and3_1
X_4224_ i_decode_stage.decode_state_o\[55\] i_decode_stage.fetch_state_i\[47\] _1982_
+ VGND VGND VPWR VPWR _1991_ sky130_fd_sc_hd__mux2_1
X_4155_ _1955_ VGND VGND VPWR VPWR _0017_ sky130_fd_sc_hd__clkbuf_1
X_3106_ _2336_ _2341_ net265 VGND VGND VPWR VPWR _1018_ sky130_fd_sc_hd__and3_1
X_4086_ _1891_ VGND VGND VPWR VPWR _1904_ sky130_fd_sc_hd__inv_2
X_3037_ _0451_ _0630_ _0632_ VGND VGND VPWR VPWR _0949_ sky130_fd_sc_hd__o21a_1
XFILLER_0_53_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_65_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_65_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4988_ clknet_leaf_0_clk_i _0168_ net281 VGND VGND VPWR VPWR i_decode_stage.reg_meta_o\[49\]
+ sky130_fd_sc_hd__dfrtp_1
X_3939_ _1110_ _0786_ _1797_ VGND VGND VPWR VPWR net182 sky130_fd_sc_hd__o21ai_1
XFILLER_0_29_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_96_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_83_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_49_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput16 dmem_rdata_i[23] VGND VGND VPWR VPWR net16 sky130_fd_sc_hd__clkbuf_1
Xinput27 dmem_rdata_i[4] VGND VGND VPWR VPWR net27 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_24_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput49 imem_rdata_i[23] VGND VGND VPWR VPWR net49 sky130_fd_sc_hd__clkbuf_4
Xinput38 imem_rdata_i[13] VGND VGND VPWR VPWR net38 sky130_fd_sc_hd__buf_2
XFILLER_0_24_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4911_ clknet_leaf_39_clk_i _0091_ net282 VGND VGND VPWR VPWR net225 sky130_fd_sc_hd__dfrtp_4
XFILLER_0_59_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_87_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_59_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4842_ clknet_leaf_33_clk_i _0022_ net287 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[26\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_7_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4773_ i_exec_stage.data_fwd_o\[17\] net138 _1839_ VGND VGND VPWR VPWR _2309_ sky130_fd_sc_hd__mux2_1
XFILLER_0_15_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3724_ _1198_ _0797_ _1608_ _1199_ _1609_ VGND VGND VPWR VPWR _1610_ sky130_fd_sc_hd__a221o_1
X_3655_ _1129_ _0594_ _1131_ _1544_ VGND VGND VPWR VPWR _1545_ sky130_fd_sc_hd__a31o_1
X_2606_ net266 i_decode_stage.reg_meta_o\[75\] _0457_ VGND VGND VPWR VPWR _0542_ sky130_fd_sc_hd__mux2_1
X_3586_ _0709_ _0545_ _1216_ VGND VGND VPWR VPWR _1479_ sky130_fd_sc_hd__o21ai_4
X_2537_ i_exec_stage.data_fwd_o\[23\] _0480_ _0460_ VGND VGND VPWR VPWR _0481_ sky130_fd_sc_hd__mux2_2
X_2468_ i_decode_stage.decode_state_o\[237\] VGND VGND VPWR VPWR _0418_ sky130_fd_sc_hd__inv_2
XFILLER_0_11_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5256_ clknet_leaf_28_clk_i _0255_ net290 VGND VGND VPWR VPWR i_decode_stage.fetch_state_i\[54\]
+ sky130_fd_sc_hd__dfrtp_1
X_4207_ _0722_ VGND VGND VPWR VPWR _1982_ sky130_fd_sc_hd__buf_12
X_2399_ i_decode_stage.decode_state_o\[122\] _0348_ _0349_ _0350_ _0351_ VGND VGND
+ VPWR VPWR _0352_ sky130_fd_sc_hd__o2111ai_4
X_5187_ clknet_leaf_23_clk_i net361 net288 VGND VGND VPWR VPWR i_mem_slice_stage.mem_state_o\[94\]
+ sky130_fd_sc_hd__dfrtp_1
X_4138_ i_decode_stage.fetch_state_i\[5\] i_decode_stage.decode_state_o\[13\] _1936_
+ VGND VGND VPWR VPWR _1947_ sky130_fd_sc_hd__mux2_1
XFILLER_0_97_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4069_ _1845_ _1886_ _1846_ VGND VGND VPWR VPWR _1887_ sky130_fd_sc_hd__o21a_1
XFILLER_0_65_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_46_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_65_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_28_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_88_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_96_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_489 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_44_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3440_ _0869_ _1228_ _1337_ _1339_ VGND VGND VPWR VPWR _1340_ sky130_fd_sc_hd__a31o_2
X_3371_ _1123_ _1118_ _0525_ VGND VGND VPWR VPWR _1273_ sky130_fd_sc_hd__mux2_1
X_5110_ clknet_leaf_14_clk_i i_mem_slice_stage.pre_data\[13\] net294 VGND VGND VPWR
+ VPWR i_mem_slice_stage.mem_state_o\[13\] sky130_fd_sc_hd__dfrtp_1
XTAP_935 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_924 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_913 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_902 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_968 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_957 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_946 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5041_ clknet_leaf_12_clk_i net161 net293 VGND VGND VPWR VPWR i_exec_stage.exec_state_o\[16\]
+ sky130_fd_sc_hd__dfrtp_1
XTAP_979 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_16_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4825_ clknet_leaf_28_clk_i _0005_ net290 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[7\]
+ sky130_fd_sc_hd__dfrtp_1
X_4756_ _2300_ VGND VGND VPWR VPWR _0273_ sky130_fd_sc_hd__clkbuf_1
X_4687_ net228 i_decode_stage.fetch_state_i\[38\] _1967_ VGND VGND VPWR VPWR _2266_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_43_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3707_ _1590_ _1592_ _1593_ VGND VGND VPWR VPWR _1594_ sky130_fd_sc_hd__or3b_1
XFILLER_0_70_150 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_3_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3638_ _0991_ _1527_ VGND VGND VPWR VPWR _1528_ sky130_fd_sc_hd__xor2_1
XFILLER_0_70_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3569_ _1198_ _1448_ _1454_ _1462_ VGND VGND VPWR VPWR _1463_ sky130_fd_sc_hd__a211o_1
X_5239_ clknet_leaf_40_clk_i _0238_ net282 VGND VGND VPWR VPWR i_decode_stage.fetch_state_i\[37\]
+ sky130_fd_sc_hd__dfrtp_1
Xclkbuf_leaf_3_clk_i clknet_2_2__leaf_clk_i VGND VGND VPWR VPWR clknet_leaf_3_clk_i
+ sky130_fd_sc_hd__clkbuf_16
XPHY_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_53_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_93_297 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_93_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_19_361 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_34_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_209 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold5 i_exec_stage.exec_state_o\[47\] VGND VGND VPWR VPWR net342 sky130_fd_sc_hd__clkdlybuf4s25_1
XFILLER_0_55_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2940_ i_exec_stage.data_fwd_o\[15\] _0322_ _0854_ VGND VGND VPWR VPWR _0855_ sky130_fd_sc_hd__o21ai_4
XFILLER_0_57_423 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_29_169 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2871_ i_exec_stage.data_fwd_o\[24\] _0726_ _0785_ VGND VGND VPWR VPWR _0786_ sky130_fd_sc_hd__o21ai_4
XFILLER_0_84_286 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_84_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4610_ i_decode_stage.decode_state_o\[119\] net40 _2207_ VGND VGND VPWR VPWR _2233_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_57_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_72_426 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_80_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_20_41 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_4_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_25_375 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4541_ i_decode_stage.decode_state_o\[128\] net50 _2179_ VGND VGND VPWR VPWR _2198_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_20_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4472_ i_decode_stage.reg_meta_o\[8\] net121 _2012_ VGND VGND VPWR VPWR _2163_ sky130_fd_sc_hd__mux2_1
X_3423_ _0590_ _1072_ VGND VGND VPWR VPWR _1323_ sky130_fd_sc_hd__nand2_1
XFILLER_0_96_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_710 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3354_ _0707_ _1256_ _1252_ VGND VGND VPWR VPWR _1257_ sky130_fd_sc_hd__a21bo_1
XTAP_721 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_732 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_743 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3285_ _1129_ _1172_ _1176_ _1186_ _1189_ VGND VGND VPWR VPWR _1190_ sky130_fd_sc_hd__a32o_1
XTAP_754 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_765 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_776 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5024_ clknet_leaf_38_clk_i i_decode_stage.decode_state_o\[139\] net131 VGND VGND
+ VPWR VPWR i_exec_stage.reg_meta_o\[3\] sky130_fd_sc_hd__dfrtp_1
XTAP_787 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_798 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_75_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4808_ _2326_ VGND VGND VPWR VPWR _0299_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_90_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4739_ i_exec_stage.data_fwd_o\[0\] i_exec_stage.valid _1839_ VGND VGND VPWR VPWR
+ _2292_ sky130_fd_sc_hd__mux2_1
XFILLER_0_31_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_101_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_478 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_66_264 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_26_117 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_81_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_62_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_10_507 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_66_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3070_ _0495_ _0980_ VGND VGND VPWR VPWR _0982_ sky130_fd_sc_hd__nand2_1
XFILLER_0_89_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_89_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_89_367 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_49_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3972_ net10 _1815_ _1819_ _1810_ VGND VGND VPWR VPWR _1820_ sky130_fd_sc_hd__a22o_1
X_2923_ _0726_ _0835_ _0836_ _0837_ VGND VGND VPWR VPWR _0838_ sky130_fd_sc_hd__a31o_1
XFILLER_0_31_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2854_ i_decode_stage.decode_state_o\[65\] _0731_ VGND VGND VPWR VPWR _0769_ sky130_fd_sc_hd__nand2_1
XFILLER_0_72_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2785_ _0344_ _0703_ VGND VGND VPWR VPWR _0704_ sky130_fd_sc_hd__or2_1
XFILLER_0_31_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_60_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_60_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_13_323 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4524_ _2189_ VGND VGND VPWR VPWR _0152_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_13_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4455_ net224 _2151_ VGND VGND VPWR VPWR _2154_ sky130_fd_sc_hd__xnor2_1
X_4386_ net139 _2042_ _2045_ _2097_ _2098_ VGND VGND VPWR VPWR _0105_ sky130_fd_sc_hd__a221o_1
XFILLER_0_40_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3406_ _0415_ _1305_ _1306_ _0424_ VGND VGND VPWR VPWR _1307_ sky130_fd_sc_hd__o211ai_1
X_3337_ _1191_ _1239_ _0421_ VGND VGND VPWR VPWR _1240_ sky130_fd_sc_hd__mux2_1
XTAP_540 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_551 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_562 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_573 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_584 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3268_ _0658_ _0673_ _0422_ VGND VGND VPWR VPWR _1173_ sky130_fd_sc_hd__mux2_1
XTAP_595 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5007_ clknet_leaf_1_clk_i _0187_ net283 VGND VGND VPWR VPWR i_decode_stage.reg_meta_o\[68\]
+ sky130_fd_sc_hd__dfrtp_1
X_3199_ _1107_ _1108_ i_exec_stage.alu_out\[1\] _1105_ VGND VGND VPWR VPWR net163
+ sky130_fd_sc_hd__a211oi_1
XFILLER_0_95_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_394 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_63_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_leaf_36_clk_i clknet_2_0__leaf_clk_i VGND VGND VPWR VPWR clknet_leaf_36_clk_i
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_98_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_309 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2570_ i_exec_stage.data_fwd_o\[18\] _0509_ _0460_ VGND VGND VPWR VPWR _0510_ sky130_fd_sc_hd__mux2_1
XFILLER_0_10_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4240_ i_decode_stage.decode_state_o\[63\] i_decode_stage.fetch_state_i\[55\] _1982_
+ VGND VGND VPWR VPWR _1999_ sky130_fd_sc_hd__mux2_1
X_4171_ _1963_ VGND VGND VPWR VPWR _0025_ sky130_fd_sc_hd__clkbuf_1
X_3122_ _0545_ _1032_ VGND VGND VPWR VPWR _1034_ sky130_fd_sc_hd__nand2_1
X_3053_ _0512_ _0963_ VGND VGND VPWR VPWR _0965_ sky130_fd_sc_hd__and2_1
XFILLER_0_77_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3955_ i_exec_stage.exec_state_o\[0\] i_exec_stage.exec_state_o\[7\] VGND VGND VPWR
+ VPWR _1805_ sky130_fd_sc_hd__and2b_1
XFILLER_0_9_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_45_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2906_ _0478_ _0805_ VGND VGND VPWR VPWR _0821_ sky130_fd_sc_hd__and2b_1
X_3886_ _0662_ _1177_ _1761_ _1762_ VGND VGND VPWR VPWR _1763_ sky130_fd_sc_hd__or4b_1
X_2837_ i_decode_stage.decode_state_o\[100\] _0751_ VGND VGND VPWR VPWR _0752_ sky130_fd_sc_hd__nand2_2
X_2768_ _0363_ _0369_ _0374_ net267 VGND VGND VPWR VPWR _0687_ sky130_fd_sc_hd__and4_1
X_2699_ _0610_ _0624_ _0540_ VGND VGND VPWR VPWR _0625_ sky130_fd_sc_hd__mux2_1
XFILLER_0_13_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4507_ i_decode_stage.reg_meta_o\[25\] net109 _2179_ VGND VGND VPWR VPWR _2181_ sky130_fd_sc_hd__mux2_1
XFILLER_0_6_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4438_ net219 net220 _2131_ VGND VGND VPWR VPWR _2140_ sky130_fd_sc_hd__and3_1
X_4369_ net205 _2081_ VGND VGND VPWR VPWR _2085_ sky130_fd_sc_hd__and2_1
XFILLER_0_6_94 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_381 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_370 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_392 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_68_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_95_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_95_189 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_76_392 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_91_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_32_440 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_99_473 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_86_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_59_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_59_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3740_ _0540_ _1624_ VGND VGND VPWR VPWR _1625_ sky130_fd_sc_hd__or2_1
XFILLER_0_6_106 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XANTENNA_19 net42 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_27_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3671_ _1199_ _1558_ _1559_ _0982_ VGND VGND VPWR VPWR _1560_ sky130_fd_sc_hd__o31a_1
X_2622_ _0451_ _0554_ _0462_ _0555_ VGND VGND VPWR VPWR _0556_ sky130_fd_sc_hd__a2bb2o_4
X_2553_ i_mem_slice_stage.mem_state_o\[59\] i_mem_slice_stage.mem_state_o\[20\] _0453_
+ VGND VGND VPWR VPWR _0496_ sky130_fd_sc_hd__mux2_1
XFILLER_0_2_345 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_23_473 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_100_309 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_2_389 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xoutput159 net159 VGND VGND VPWR VPWR dmem_addr_o[7] sky130_fd_sc_hd__clkbuf_4
Xoutput137 net137 VGND VGND VPWR VPWR dmem_addr_o[15] sky130_fd_sc_hd__clkbuf_4
Xoutput148 net148 VGND VGND VPWR VPWR dmem_addr_o[26] sky130_fd_sc_hd__clkbuf_4
X_2484_ _0406_ _0407_ _0411_ _0433_ VGND VGND VPWR VPWR _0434_ sky130_fd_sc_hd__a31o_1
X_5272_ clknet_leaf_35_clk_i _0271_ VGND VGND VPWR VPWR i_exec_stage.data_fwd_o\[6\]
+ sky130_fd_sc_hd__dfxtp_1
X_4223_ _1990_ VGND VGND VPWR VPWR _0050_ sky130_fd_sc_hd__clkbuf_1
X_4154_ i_decode_stage.fetch_state_i\[13\] i_decode_stage.decode_state_o\[21\] _1936_
+ VGND VGND VPWR VPWR _1955_ sky130_fd_sc_hd__mux2_1
X_3105_ _1004_ _1012_ _1013_ _1016_ VGND VGND VPWR VPWR _1017_ sky130_fd_sc_hd__a211o_1
X_4085_ _1885_ _1889_ _1902_ VGND VGND VPWR VPWR _1903_ sky130_fd_sc_hd__a21o_1
X_3036_ _0656_ _0934_ VGND VGND VPWR VPWR _0948_ sky130_fd_sc_hd__and2b_1
XFILLER_0_77_123 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_77_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_46_510 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4987_ clknet_leaf_0_clk_i _0167_ net281 VGND VGND VPWR VPWR i_decode_stage.reg_meta_o\[48\]
+ sky130_fd_sc_hd__dfrtp_1
X_3938_ _1110_ net196 VGND VGND VPWR VPWR _1797_ sky130_fd_sc_hd__nand2_1
XFILLER_0_61_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3869_ _0422_ _1718_ _1746_ _0523_ VGND VGND VPWR VPWR _1747_ sky130_fd_sc_hd__o211a_1
XFILLER_0_5_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_281 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_96_421 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xinput17 dmem_rdata_i[24] VGND VGND VPWR VPWR net17 sky130_fd_sc_hd__clkbuf_1
Xinput28 dmem_rdata_i[5] VGND VGND VPWR VPWR net28 sky130_fd_sc_hd__clkbuf_1
Xinput39 imem_rdata_i[14] VGND VGND VPWR VPWR net39 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_20_421 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_74_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_99_281 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4910_ clknet_leaf_31_clk_i _0090_ net285 VGND VGND VPWR VPWR net222 sky130_fd_sc_hd__dfrtp_4
X_4841_ clknet_leaf_31_clk_i _0021_ net285 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[25\]
+ sky130_fd_sc_hd__dfrtp_1
X_4772_ _2308_ VGND VGND VPWR VPWR _0281_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_82_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3723_ _0417_ _0484_ VGND VGND VPWR VPWR _1609_ sky130_fd_sc_hd__nor2_1
X_3654_ _0709_ _1542_ _1543_ VGND VGND VPWR VPWR _1544_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_82_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2605_ i_mem_slice_stage.mem_state_o\[102\] _0452_ _0541_ _0455_ VGND VGND VPWR VPWR
+ net266 sky130_fd_sc_hd__a22o_1
XFILLER_0_70_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_70_376 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3585_ _0540_ _0525_ _0586_ _1348_ VGND VGND VPWR VPWR _1478_ sky130_fd_sc_hd__or4_1
XFILLER_0_100_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2536_ net256 i_decode_stage.reg_meta_o\[66\] _0457_ VGND VGND VPWR VPWR _0480_ sky130_fd_sc_hd__mux2_1
X_2467_ i_decode_stage.decode_state_o\[237\] _0416_ VGND VGND VPWR VPWR _0417_ sky130_fd_sc_hd__nand2_8
X_5255_ clknet_leaf_28_clk_i _0254_ net291 VGND VGND VPWR VPWR i_decode_stage.fetch_state_i\[53\]
+ sky130_fd_sc_hd__dfrtp_1
X_4206_ _1981_ VGND VGND VPWR VPWR _0042_ sky130_fd_sc_hd__clkbuf_1
X_2398_ i_decode_stage.decode_state_o\[121\] i_exec_stage.data_fwd_o\[35\] VGND VGND
+ VPWR VPWR _0351_ sky130_fd_sc_hd__or2b_1
X_5186_ clknet_leaf_25_clk_i net348 net289 VGND VGND VPWR VPWR i_mem_slice_stage.mem_state_o\[93\]
+ sky130_fd_sc_hd__dfrtp_1
X_4137_ _1946_ VGND VGND VPWR VPWR _0008_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_78_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4068_ _1843_ _1844_ VGND VGND VPWR VPWR _1886_ sky130_fd_sc_hd__and2b_1
X_3019_ i_exec_stage.data_fwd_o\[11\] _0311_ _0316_ _0320_ VGND VGND VPWR VPWR _0931_
+ sky130_fd_sc_hd__or4_1
XFILLER_0_65_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_61_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_73_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_96_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_1130 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_373 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_8_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_52_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_52_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3370_ _0662_ _1115_ _1255_ VGND VGND VPWR VPWR _1272_ sky130_fd_sc_hd__o21a_1
XTAP_925 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_914 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_903 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_958 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_947 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_936 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5040_ clknet_leaf_11_clk_i net160 net292 VGND VGND VPWR VPWR i_exec_stage.exec_state_o\[15\]
+ sky130_fd_sc_hd__dfrtp_1
XTAP_969 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_18_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_26_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_75_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_47_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_7_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4824_ clknet_leaf_26_clk_i _0004_ net289 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[6\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_90_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4755_ i_exec_stage.data_fwd_o\[8\] net159 _1839_ VGND VGND VPWR VPWR _2300_ sky130_fd_sc_hd__mux2_1
XFILLER_0_50_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3706_ _0415_ _0809_ _1257_ _1479_ VGND VGND VPWR VPWR _1593_ sky130_fd_sc_hd__o22a_1
X_4686_ _2265_ VGND VGND VPWR VPWR _0238_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_31_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3637_ _1492_ _1525_ _1526_ VGND VGND VPWR VPWR _1527_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_3_473 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3568_ _1144_ _1455_ _1459_ _1204_ _1461_ VGND VGND VPWR VPWR _1462_ sky130_fd_sc_hd__a221o_1
X_2519_ i_mem_slice_stage.mem_state_o\[63\] i_mem_slice_stage.mem_state_o\[24\] _0453_
+ VGND VGND VPWR VPWR _0466_ sky130_fd_sc_hd__mux2_2
X_3499_ _0589_ _0523_ VGND VGND VPWR VPWR _1396_ sky130_fd_sc_hd__nand2_2
X_5238_ clknet_leaf_30_clk_i _0237_ net282 VGND VGND VPWR VPWR i_decode_stage.fetch_state_i\[36\]
+ sky130_fd_sc_hd__dfrtp_1
X_5169_ clknet_leaf_42_clk_i net396 net280 VGND VGND VPWR VPWR i_mem_slice_stage.mem_state_o\[76\]
+ sky130_fd_sc_hd__dfrtp_1
XPHY_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_93_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_19_373 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_46_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_81_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_46_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_89_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold6 i_exec_stage.exec_state_o\[69\] VGND VGND VPWR VPWR net343 sky130_fd_sc_hd__clkdlybuf4s25_1
XFILLER_0_57_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_84_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2870_ i_decode_stage.reg_meta_o\[29\] _0727_ _0386_ _0784_ VGND VGND VPWR VPWR _0785_
+ sky130_fd_sc_hd__a211o_1
XFILLER_0_72_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_13_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4540_ _2197_ VGND VGND VPWR VPWR _0160_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_20_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_25_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4471_ _2162_ VGND VGND VPWR VPWR _0126_ sky130_fd_sc_hd__clkbuf_1
X_3422_ _0582_ _0545_ VGND VGND VPWR VPWR _1322_ sky130_fd_sc_hd__nand2_2
XFILLER_0_0_421 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_700 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3353_ _0525_ _0539_ _1255_ VGND VGND VPWR VPWR _1256_ sky130_fd_sc_hd__o21a_1
XTAP_711 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_722 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_733 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3284_ _0448_ _1188_ _0584_ VGND VGND VPWR VPWR _1189_ sky130_fd_sc_hd__a21o_1
XTAP_744 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_755 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_766 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_777 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5023_ clknet_leaf_39_clk_i i_decode_stage.decode_state_o\[138\] net282 VGND VGND
+ VPWR VPWR i_exec_stage.reg_meta_o\[2\] sky130_fd_sc_hd__dfrtp_1
XTAP_788 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_799 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_8_510 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_0_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4807_ i_exec_stage.data_fwd_o\[34\] i_decode_stage.decode_state_o\[137\] _1838_
+ VGND VGND VPWR VPWR _2326_ sky130_fd_sc_hd__mux2_1
X_2999_ _0672_ _0910_ VGND VGND VPWR VPWR _0911_ sky130_fd_sc_hd__nor2_2
XFILLER_0_90_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4738_ _2291_ VGND VGND VPWR VPWR _0264_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_31_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4669_ i_decode_stage.fetch_state_i\[26\] _1929_ _2133_ VGND VGND VPWR VPWR _0227_
+ sky130_fd_sc_hd__a21o_1
XFILLER_0_3_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_39_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_47_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_184 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_66_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_89_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3971_ net2 net19 i_exec_stage.exec_state_o\[8\] VGND VGND VPWR VPWR _1819_ sky130_fd_sc_hd__mux2_1
XFILLER_0_9_307 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_97_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2922_ i_exec_stage.data_fwd_o\[14\] _0332_ _0333_ _0334_ VGND VGND VPWR VPWR _0837_
+ sky130_fd_sc_hd__and4b_1
XFILLER_0_45_405 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_45_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2853_ i_exec_stage.data_fwd_o\[26\] _0726_ _0767_ VGND VGND VPWR VPWR _0768_ sky130_fd_sc_hd__o21ai_4
XFILLER_0_25_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2784_ _0450_ _0701_ _0702_ VGND VGND VPWR VPWR _0703_ sky130_fd_sc_hd__o21a_2
XFILLER_0_86_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4523_ i_decode_stage.reg_meta_o\[33\] net118 _2179_ VGND VGND VPWR VPWR _2189_ sky130_fd_sc_hd__mux2_1
Xclkbuf_leaf_2_clk_i clknet_2_0__leaf_clk_i VGND VGND VPWR VPWR clknet_leaf_2_clk_i
+ sky130_fd_sc_hd__clkbuf_16
X_4454_ _2149_ _2153_ net223 _1929_ VGND VGND VPWR VPWR _0118_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_0_21_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4385_ net208 _1927_ VGND VGND VPWR VPWR _2098_ sky130_fd_sc_hd__and2_1
X_3405_ _1198_ _1305_ _0666_ _0417_ VGND VGND VPWR VPWR _1306_ sky130_fd_sc_hd__o2bb2a_1
X_3336_ _0683_ _0883_ _0465_ VGND VGND VPWR VPWR _1239_ sky130_fd_sc_hd__mux2_1
XTAP_530 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_541 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_552 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_563 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_574 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_585 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3267_ _0590_ _1171_ VGND VGND VPWR VPWR _1172_ sky130_fd_sc_hd__or2_1
X_5006_ clknet_leaf_1_clk_i _0186_ net283 VGND VGND VPWR VPWR i_decode_stage.reg_meta_o\[67\]
+ sky130_fd_sc_hd__dfrtp_1
XTAP_596 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3198_ i_exec_stage.alu_out\[0\] _1106_ VGND VGND VPWR VPWR _1108_ sky130_fd_sc_hd__or2_1
XFILLER_0_36_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_460 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_86_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_52_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_79_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4170_ i_decode_stage.fetch_state_i\[21\] i_decode_stage.decode_state_o\[29\] _1936_
+ VGND VGND VPWR VPWR _1963_ sky130_fd_sc_hd__mux2_1
X_3121_ _0545_ _1032_ VGND VGND VPWR VPWR _1033_ sky130_fd_sc_hd__or2_1
XFILLER_0_26_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3052_ _0512_ _0963_ VGND VGND VPWR VPWR _0964_ sky130_fd_sc_hd__nor2_2
XFILLER_0_89_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_26_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3954_ _1110_ _1030_ _1785_ _1112_ _1786_ VGND VGND VPWR VPWR net191 sky130_fd_sc_hd__o221ai_2
X_3885_ _0345_ _0540_ _0537_ VGND VGND VPWR VPWR _1762_ sky130_fd_sc_hd__or3_1
XFILLER_0_85_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2905_ _0500_ _0814_ VGND VGND VPWR VPWR _0820_ sky130_fd_sc_hd__and2b_1
X_2836_ _2333_ _0339_ VGND VGND VPWR VPWR _0751_ sky130_fd_sc_hd__nor2_4
XFILLER_0_5_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2767_ _0376_ _0377_ _0378_ i_decode_stage.reg_meta_o\[47\] VGND VGND VPWR VPWR _0686_
+ sky130_fd_sc_hd__o31a_1
XFILLER_0_13_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2698_ _0344_ _0617_ _0623_ VGND VGND VPWR VPWR _0624_ sky130_fd_sc_hd__a21o_1
XFILLER_0_77_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4506_ _2180_ VGND VGND VPWR VPWR _0143_ sky130_fd_sc_hd__clkbuf_1
X_4437_ net150 _1924_ VGND VGND VPWR VPWR _2139_ sky130_fd_sc_hd__or2_1
XTAP_360 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4368_ net135 _2047_ _2048_ _2083_ _2084_ VGND VGND VPWR VPWR _0101_ sky130_fd_sc_hd__o221a_1
X_3319_ _1220_ _1221_ _1222_ _0590_ VGND VGND VPWR VPWR _1223_ sky130_fd_sc_hd__o22a_1
X_4299_ i_decode_stage.decode_state_o\[236\] _1840_ _2034_ VGND VGND VPWR VPWR _0082_
+ sky130_fd_sc_hd__o21a_1
XTAP_393 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_382 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_371 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_113 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_24_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_99_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_99_485 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_86_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_86_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_6_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_42_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3670_ _0417_ _0495_ _0981_ _1198_ VGND VGND VPWR VPWR _1559_ sky130_fd_sc_hd__a2bb2o_1
X_2621_ _0346_ i_decode_stage.decode_state_o\[132\] VGND VGND VPWR VPWR _0555_ sky130_fd_sc_hd__or2b_1
XFILLER_0_2_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_485 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2552_ _0451_ _0490_ _0492_ _0494_ VGND VGND VPWR VPWR _0495_ sky130_fd_sc_hd__a2bb2o_4
XFILLER_0_10_124 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5271_ clknet_leaf_4_clk_i _0270_ VGND VGND VPWR VPWR i_exec_stage.data_fwd_o\[5\]
+ sky130_fd_sc_hd__dfxtp_1
Xoutput138 net138 VGND VGND VPWR VPWR dmem_addr_o[16] sky130_fd_sc_hd__clkbuf_4
Xoutput149 net149 VGND VGND VPWR VPWR dmem_addr_o[27] sky130_fd_sc_hd__clkbuf_4
X_2483_ _0405_ _0415_ _0426_ _0432_ VGND VGND VPWR VPWR _0433_ sky130_fd_sc_hd__o211ai_1
X_4222_ i_decode_stage.decode_state_o\[54\] i_decode_stage.fetch_state_i\[46\] _1982_
+ VGND VGND VPWR VPWR _1990_ sky130_fd_sc_hd__mux2_1
X_4153_ _1954_ VGND VGND VPWR VPWR _0016_ sky130_fd_sc_hd__clkbuf_1
X_3104_ _1014_ _1015_ VGND VGND VPWR VPWR _1016_ sky130_fd_sc_hd__nor2_2
X_4084_ _1892_ _1894_ _1896_ _1901_ VGND VGND VPWR VPWR _1902_ sky130_fd_sc_hd__or4_1
XFILLER_0_37_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3035_ _0920_ _0944_ _0946_ VGND VGND VPWR VPWR _0947_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_77_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_77_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_leaf_20_clk_i clknet_2_3__leaf_clk_i VGND VGND VPWR VPWR clknet_leaf_20_clk_i
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_92_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4986_ clknet_leaf_44_clk_i _0166_ net281 VGND VGND VPWR VPWR i_decode_stage.reg_meta_o\[47\]
+ sky130_fd_sc_hd__dfrtp_1
X_3937_ _1796_ VGND VGND VPWR VPWR net181 sky130_fd_sc_hd__clkbuf_1
Xclkbuf_leaf_35_clk_i clknet_2_1__leaf_clk_i VGND VGND VPWR VPWR clknet_leaf_35_clk_i
+ sky130_fd_sc_hd__clkbuf_16
X_3868_ _0345_ _0537_ _1063_ _0540_ VGND VGND VPWR VPWR _1746_ sky130_fd_sc_hd__a211o_1
XFILLER_0_61_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3799_ _1680_ VGND VGND VPWR VPWR _1681_ sky130_fd_sc_hd__inv_2
X_2819_ i_decode_stage.decode_state_o\[69\] _0731_ _0733_ VGND VGND VPWR VPWR _0734_
+ sky130_fd_sc_hd__a21oi_1
XFILLER_0_41_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_96_433 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_96_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_68_157 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_76_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput18 dmem_rdata_i[25] VGND VGND VPWR VPWR net18 sky130_fd_sc_hd__clkbuf_1
Xinput29 dmem_rdata_i[6] VGND VGND VPWR VPWR net29 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_20_433 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_20_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_87_422 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_99_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_90_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4840_ clknet_leaf_43_clk_i _0020_ net280 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[24\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_7_405 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_74_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_7_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4771_ i_exec_stage.data_fwd_o\[16\] net137 _1839_ VGND VGND VPWR VPWR _2308_ sky130_fd_sc_hd__mux2_1
X_3722_ _0484_ _0796_ VGND VGND VPWR VPWR _1608_ sky130_fd_sc_hd__nand2_1
X_3653_ _1041_ _1154_ _0713_ VGND VGND VPWR VPWR _1543_ sky130_fd_sc_hd__o21a_1
X_2604_ i_mem_slice_stage.mem_state_o\[70\] i_mem_slice_stage.mem_state_o\[31\] _0453_
+ VGND VGND VPWR VPWR _0541_ sky130_fd_sc_hd__mux2_1
XFILLER_0_70_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3584_ _0709_ _0594_ VGND VGND VPWR VPWR _1477_ sky130_fd_sc_hd__nand2_1
X_2535_ i_mem_slice_stage.mem_state_o\[93\] _0452_ _0479_ _0455_ VGND VGND VPWR VPWR
+ net256 sky130_fd_sc_hd__a22o_1
X_2466_ i_decode_stage.decode_state_o\[236\] i_decode_stage.decode_state_o\[238\]
+ i_decode_stage.decode_state_o\[239\] VGND VGND VPWR VPWR _0416_ sky130_fd_sc_hd__and3_2
X_5254_ clknet_leaf_32_clk_i _0253_ net287 VGND VGND VPWR VPWR i_decode_stage.fetch_state_i\[52\]
+ sky130_fd_sc_hd__dfrtp_1
X_4205_ i_decode_stage.decode_state_o\[46\] i_decode_stage.fetch_state_i\[38\] _1840_
+ VGND VGND VPWR VPWR _1981_ sky130_fd_sc_hd__mux2_1
X_5185_ clknet_leaf_23_clk_i net359 net288 VGND VGND VPWR VPWR i_mem_slice_stage.mem_state_o\[92\]
+ sky130_fd_sc_hd__dfrtp_1
X_4136_ i_decode_stage.fetch_state_i\[4\] i_decode_stage.decode_state_o\[12\] _1936_
+ VGND VGND VPWR VPWR _1946_ sky130_fd_sc_hd__mux2_1
X_2397_ i_exec_stage.data_fwd_o\[35\] i_decode_stage.decode_state_o\[121\] VGND VGND
+ VPWR VPWR _0350_ sky130_fd_sc_hd__or2b_1
XFILLER_0_3_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4067_ _1852_ _1884_ VGND VGND VPWR VPWR _1885_ sky130_fd_sc_hd__or2_1
XFILLER_0_64_71 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3018_ _0324_ _0326_ i_decode_stage.reg_meta_o\[16\] VGND VGND VPWR VPWR _0930_ sky130_fd_sc_hd__o21a_1
XFILLER_0_64_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_78_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_65_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_93_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4969_ clknet_leaf_10_clk_i _0149_ net292 VGND VGND VPWR VPWR i_decode_stage.reg_meta_o\[30\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_46_374 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_69_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_69_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1131 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1120 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_25_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_100_57 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_20_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_926 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_915 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_904 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_959 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_948 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_937 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4823_ clknet_leaf_33_clk_i _0003_ net288 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[5\]
+ sky130_fd_sc_hd__dfrtp_1
X_4754_ _2299_ VGND VGND VPWR VPWR _0272_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_43_344 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3705_ _1198_ _0806_ _0807_ _1199_ _1591_ VGND VGND VPWR VPWR _1592_ sky130_fd_sc_hd__a221o_1
X_4685_ net227 i_decode_stage.fetch_state_i\[37\] _1967_ VGND VGND VPWR VPWR _2265_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_70_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_101_405 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_3_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3636_ _0964_ _0972_ _0965_ VGND VGND VPWR VPWR _1526_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_3_485 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3567_ _0417_ _0608_ _1460_ _1199_ VGND VGND VPWR VPWR _1461_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_0_101_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2518_ _0343_ VGND VGND VPWR VPWR _0465_ sky130_fd_sc_hd__inv_6
XFILLER_0_11_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5306_ clknet_leaf_38_clk_i _0305_ net286 VGND VGND VPWR VPWR i_decode_stage.valid_i
+ sky130_fd_sc_hd__dfrtp_1
X_5237_ clknet_leaf_38_clk_i _0236_ net282 VGND VGND VPWR VPWR i_decode_stage.fetch_state_i\[35\]
+ sky130_fd_sc_hd__dfrtp_1
X_3498_ _1198_ _0927_ _1149_ VGND VGND VPWR VPWR _1395_ sky130_fd_sc_hd__a21o_1
X_2449_ _0396_ _0397_ _0398_ net253 VGND VGND VPWR VPWR _0399_ sky130_fd_sc_hd__nor4_2
X_5168_ clknet_leaf_42_clk_i net403 net281 VGND VGND VPWR VPWR i_mem_slice_stage.mem_state_o\[75\]
+ sky130_fd_sc_hd__dfrtp_1
X_5099_ clknet_leaf_15_clk_i i_mem_slice_stage.pre_data\[2\] net294 VGND VGND VPWR
+ VPWR i_mem_slice_stage.mem_state_o\[2\] sky130_fd_sc_hd__dfrtp_1
X_4119_ net60 _1928_ _1934_ VGND VGND VPWR VPWR _1935_ sky130_fd_sc_hd__nor3_2
XFILLER_0_78_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_91_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_480 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_19_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_61_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold7 i_exec_stage.reg_meta_o\[2\] VGND VGND VPWR VPWR net344 sky130_fd_sc_hd__clkdlybuf4s25_1
XFILLER_0_69_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_69_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_25_355 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_52_141 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4470_ i_decode_stage.reg_meta_o\[7\] net110 _2012_ VGND VGND VPWR VPWR _2162_ sky130_fd_sc_hd__mux2_1
XFILLER_0_40_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3421_ _0415_ _0911_ _1320_ _0424_ VGND VGND VPWR VPWR _1321_ sky130_fd_sc_hd__o211a_1
X_3352_ _0540_ _0525_ _0545_ VGND VGND VPWR VPWR _1255_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_0_433 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_701 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_29_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_712 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_723 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_734 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3283_ _0590_ _1179_ _1187_ _1184_ VGND VGND VPWR VPWR _1188_ sky130_fd_sc_hd__o31ai_1
XTAP_745 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_756 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_767 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5022_ clknet_leaf_38_clk_i i_decode_stage.decode_state_o\[137\] net131 VGND VGND
+ VPWR VPWR i_exec_stage.reg_meta_o\[1\] sky130_fd_sc_hd__dfrtp_1
XTAP_778 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_789 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4806_ _2325_ VGND VGND VPWR VPWR _0298_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_35_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_56_491 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2998_ _0384_ _0908_ _0909_ VGND VGND VPWR VPWR _0910_ sky130_fd_sc_hd__o21ba_1
X_4737_ net224 i_decode_stage.fetch_state_i\[63\] _1927_ VGND VGND VPWR VPWR _2291_
+ sky130_fd_sc_hd__mux2_1
X_4668_ i_decode_stage.fetch_state_i\[25\] _1929_ _2127_ VGND VGND VPWR VPWR _0226_
+ sky130_fd_sc_hd__a21o_1
X_3619_ _0972_ _1508_ _0966_ VGND VGND VPWR VPWR _1510_ sky130_fd_sc_hd__o21ai_1
X_4599_ _2227_ VGND VGND VPWR VPWR _0189_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_86_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_225 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3970_ net12 _1809_ _1818_ VGND VGND VPWR VPWR i_mem_slice_stage.pre_data\[1\] sky130_fd_sc_hd__a21o_1
XFILLER_0_57_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2921_ _0324_ _0326_ i_decode_stage.reg_meta_o\[19\] VGND VGND VPWR VPWR _0836_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_45_417 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_57_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_5_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2852_ i_decode_stage.reg_meta_o\[31\] _0727_ _0386_ _0766_ VGND VGND VPWR VPWR _0767_
+ sky130_fd_sc_hd__a211o_1
X_2783_ i_decode_stage.decode_state_o\[126\] _0631_ i_decode_stage.decode_state_o\[138\]
+ _0491_ _0347_ VGND VGND VPWR VPWR _0702_ sky130_fd_sc_hd__a221o_1
X_4522_ _2188_ VGND VGND VPWR VPWR _0151_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_53_472 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4453_ _2042_ _2152_ VGND VGND VPWR VPWR _2153_ sky130_fd_sc_hd__nor2_1
XFILLER_0_13_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3404_ _0666_ _0875_ VGND VGND VPWR VPWR _1305_ sky130_fd_sc_hd__nor2_1
X_4384_ _2095_ _2096_ VGND VGND VPWR VPWR _2097_ sky130_fd_sc_hd__nor2_1
X_3335_ _0662_ _0625_ _1237_ VGND VGND VPWR VPWR _1238_ sky130_fd_sc_hd__o21ai_2
XTAP_520 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_531 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_542 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3266_ _1169_ _1170_ _0660_ VGND VGND VPWR VPWR _1171_ sky130_fd_sc_hd__mux2_1
XTAP_553 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_564 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_575 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5005_ clknet_leaf_2_clk_i _0185_ net283 VGND VGND VPWR VPWR i_decode_stage.reg_meta_o\[66\]
+ sky130_fd_sc_hd__dfrtp_1
XTAP_586 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_597 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_56_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_56_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_56_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3197_ i_exec_stage.alu_out\[0\] _1106_ VGND VGND VPWR VPWR _1107_ sky130_fd_sc_hd__nand2_1
XFILLER_0_95_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_48_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_31_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_31_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_39_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_501 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_35_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_35_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_22_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3120_ _0384_ _1030_ _0752_ _1031_ VGND VGND VPWR VPWR _1032_ sky130_fd_sc_hd__o211a_1
XFILLER_0_89_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3051_ _2333_ _0961_ _0962_ VGND VGND VPWR VPWR _0963_ sky130_fd_sc_hd__a21o_1
XFILLER_0_26_64 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_92_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_85_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3953_ _1110_ _1020_ _0855_ _1112_ _1784_ VGND VGND VPWR VPWR net190 sky130_fd_sc_hd__o221ai_2
XFILLER_0_42_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3884_ _0422_ _1732_ VGND VGND VPWR VPWR _1761_ sky130_fd_sc_hd__nor2_1
XFILLER_0_42_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_45_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2904_ _0484_ _0796_ VGND VGND VPWR VPWR _0819_ sky130_fd_sc_hd__and2b_1
X_2835_ i_decode_stage.decode_state_o\[67\] _0731_ VGND VGND VPWR VPWR _0750_ sky130_fd_sc_hd__nand2_1
X_2766_ _0673_ _0684_ _0422_ VGND VGND VPWR VPWR _0685_ sky130_fd_sc_hd__mux2_1
XFILLER_0_13_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_41_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2697_ _0465_ _0622_ VGND VGND VPWR VPWR _0623_ sky130_fd_sc_hd__and2_1
X_4505_ i_decode_stage.reg_meta_o\[24\] net108 _2179_ VGND VGND VPWR VPWR _2180_ sky130_fd_sc_hd__mux2_1
X_4436_ net219 _1928_ _2135_ _2138_ VGND VGND VPWR VPWR _0115_ sky130_fd_sc_hd__a22o_1
X_4367_ net204 _1840_ VGND VGND VPWR VPWR _2084_ sky130_fd_sc_hd__or2_1
X_3318_ _1059_ _1079_ _0523_ VGND VGND VPWR VPWR _1222_ sky130_fd_sc_hd__mux2_1
XTAP_350 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4298_ net37 _2031_ _2033_ _1928_ VGND VGND VPWR VPWR _2034_ sky130_fd_sc_hd__a211o_1
XTAP_394 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_383 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_372 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_361 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3249_ i_decode_stage.decode_state_o\[239\] _0429_ VGND VGND VPWR VPWR _1155_ sky130_fd_sc_hd__and2_1
XPHY_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_68_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_95_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_95_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_64_501 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_91_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_99_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_2_1__f_clk_i clknet_0_clk_i VGND VGND VPWR VPWR clknet_2_1__leaf_clk_i sky130_fd_sc_hd__clkbuf_16
XFILLER_0_59_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_leaf_1_clk_i clknet_2_0__leaf_clk_i VGND VGND VPWR VPWR clknet_leaf_1_clk_i
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_27_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_82_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2620_ i_exec_stage.data_fwd_o\[29\] _0553_ _0460_ VGND VGND VPWR VPWR _0554_ sky130_fd_sc_hd__mux2_1
XFILLER_0_88_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_2_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2551_ i_decode_stage.decode_state_o\[123\] _0493_ VGND VGND VPWR VPWR _0494_ sky130_fd_sc_hd__nand2_1
X_2482_ _0428_ _0405_ _0431_ VGND VGND VPWR VPWR _0432_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_23_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5270_ clknet_leaf_36_clk_i _0269_ VGND VGND VPWR VPWR i_exec_stage.data_fwd_o\[4\]
+ sky130_fd_sc_hd__dfxtp_1
Xoutput139 net139 VGND VGND VPWR VPWR dmem_addr_o[17] sky130_fd_sc_hd__clkbuf_4
X_4221_ _1989_ VGND VGND VPWR VPWR _0049_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_10_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_56_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4152_ i_decode_stage.fetch_state_i\[12\] i_decode_stage.decode_state_o\[20\] _1936_
+ VGND VGND VPWR VPWR _1954_ sky130_fd_sc_hd__mux2_1
X_3103_ _0556_ _0743_ VGND VGND VPWR VPWR _1015_ sky130_fd_sc_hd__and2_1
X_4083_ _1897_ _1898_ _1899_ _1900_ VGND VGND VPWR VPWR _1901_ sky130_fd_sc_hd__or4_1
X_3034_ _0945_ _0919_ VGND VGND VPWR VPWR _0946_ sky130_fd_sc_hd__nand2_1
XFILLER_0_77_169 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4985_ clknet_leaf_44_clk_i _0165_ net281 VGND VGND VPWR VPWR i_decode_stage.reg_meta_o\[46\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_92_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3936_ _1795_ net195 _1110_ VGND VGND VPWR VPWR _1796_ sky130_fd_sc_hd__mux2_1
X_3867_ _1025_ _0746_ _1017_ VGND VGND VPWR VPWR _1745_ sky130_fd_sc_hd__nand3_1
XFILLER_0_73_364 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3798_ _1642_ _1679_ _0394_ VGND VGND VPWR VPWR _1680_ sky130_fd_sc_hd__mux2_1
X_2818_ _0732_ _0339_ _0384_ VGND VGND VPWR VPWR _0733_ sky130_fd_sc_hd__o21ai_4
XFILLER_0_14_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2749_ i_exec_stage.data_fwd_o\[9\] _0352_ _0355_ _0357_ VGND VGND VPWR VPWR _0670_
+ sky130_fd_sc_hd__or4_1
XFILLER_0_1_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4419_ net216 _1928_ _2121_ _2124_ VGND VGND VPWR VPWR _0112_ sky130_fd_sc_hd__a22o_1
XFILLER_0_96_445 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_68_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_96_489 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_37_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_49_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_68_169 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_64_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput19 dmem_rdata_i[26] VGND VGND VPWR VPWR net19 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_91_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_24_239 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_58_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_20_445 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_20_489 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_87_434 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_47_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_59_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_74_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_417 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4770_ _2307_ VGND VGND VPWR VPWR _0280_ sky130_fd_sc_hd__clkbuf_1
X_3721_ _1286_ _1501_ _1606_ _1278_ VGND VGND VPWR VPWR _1607_ sky130_fd_sc_hd__o22a_1
XFILLER_0_99_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3652_ _1373_ _1541_ _0590_ VGND VGND VPWR VPWR _1542_ sky130_fd_sc_hd__mux2_1
XFILLER_0_55_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_70_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2603_ _0527_ VGND VGND VPWR VPWR _0540_ sky130_fd_sc_hd__buf_6
X_3583_ _1298_ _1475_ _0590_ VGND VGND VPWR VPWR _1476_ sky130_fd_sc_hd__mux2_1
X_2534_ i_mem_slice_stage.mem_state_o\[61\] i_mem_slice_stage.mem_state_o\[22\] _0453_
+ VGND VGND VPWR VPWR _0479_ sky130_fd_sc_hd__mux2_2
X_2465_ _0414_ VGND VGND VPWR VPWR _0415_ sky130_fd_sc_hd__clkbuf_4
X_5253_ clknet_leaf_28_clk_i _0252_ net291 VGND VGND VPWR VPWR i_decode_stage.fetch_state_i\[51\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_54_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4204_ _1980_ VGND VGND VPWR VPWR _0041_ sky130_fd_sc_hd__clkbuf_1
X_2396_ i_exec_stage.data_fwd_o\[33\] i_decode_stage.decode_state_o\[119\] VGND VGND
+ VPWR VPWR _0349_ sky130_fd_sc_hd__or2b_1
X_5184_ clknet_leaf_22_clk_i i_exec_stage.exec_state_o\[59\] net288 VGND VGND VPWR
+ VPWR i_mem_slice_stage.mem_state_o\[91\] sky130_fd_sc_hd__dfrtp_1
X_4135_ _1945_ VGND VGND VPWR VPWR _0007_ sky130_fd_sc_hd__clkbuf_1
X_4066_ _1866_ _1867_ _1879_ _1882_ _1883_ VGND VGND VPWR VPWR _1884_ sky130_fd_sc_hd__o32a_1
X_3017_ _2336_ _2341_ net243 VGND VGND VPWR VPWR _0929_ sky130_fd_sc_hd__and3_1
XFILLER_0_64_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_78_489 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_38_309 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4968_ clknet_leaf_10_clk_i _0148_ net292 VGND VGND VPWR VPWR i_decode_stage.reg_meta_o\[29\]
+ sky130_fd_sc_hd__dfrtp_1
X_3919_ net196 _1106_ VGND VGND VPWR VPWR _1786_ sky130_fd_sc_hd__nand2_1
XFILLER_0_46_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4899_ clknet_leaf_26_clk_i _0079_ net289 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[233\]
+ sky130_fd_sc_hd__dfrtp_4
XTAP_1132 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1121 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1110 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_69_478 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_37_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_100_69 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_916 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_905 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_253 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_949 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_938 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_927 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_34_clk_i clknet_2_3__leaf_clk_i VGND VGND VPWR VPWR clknet_leaf_34_clk_i
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_87_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_34_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4822_ clknet_leaf_33_clk_i _0002_ net288 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[4\]
+ sky130_fd_sc_hd__dfrtp_1
X_4753_ i_exec_stage.data_fwd_o\[7\] net158 _1839_ VGND VGND VPWR VPWR _2299_ sky130_fd_sc_hd__mux2_1
XFILLER_0_7_225 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_28_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3704_ _0417_ _0478_ VGND VGND VPWR VPWR _1591_ sky130_fd_sc_hd__nor2_1
X_4684_ _2264_ VGND VGND VPWR VPWR _0237_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_43_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3635_ _0966_ _0975_ VGND VGND VPWR VPWR _1525_ sky130_fd_sc_hd__nand2_1
XFILLER_0_101_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_3_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3566_ _0608_ _0857_ VGND VGND VPWR VPWR _1460_ sky130_fd_sc_hd__nand2_1
X_3497_ _1088_ _1171_ _1183_ _1287_ _1393_ VGND VGND VPWR VPWR _1394_ sky130_fd_sc_hd__o221a_1
X_5305_ clknet_leaf_35_clk_i _0304_ VGND VGND VPWR VPWR i_exec_stage.data_fwd_o\[39\]
+ sky130_fd_sc_hd__dfxtp_1
X_2517_ _0451_ _0461_ _0462_ _0463_ VGND VGND VPWR VPWR _0464_ sky130_fd_sc_hd__a2bb2o_4
XFILLER_0_59_83 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2448_ i_decode_stage.reg_meta_o\[81\] net274 _0371_ _0372_ VGND VGND VPWR VPWR _0398_
+ sky130_fd_sc_hd__nand4_1
X_5236_ clknet_leaf_33_clk_i _0235_ net287 VGND VGND VPWR VPWR i_decode_stage.fetch_state_i\[34\]
+ sky130_fd_sc_hd__dfrtp_1
X_5167_ clknet_leaf_42_clk_i net404 net280 VGND VGND VPWR VPWR i_mem_slice_stage.mem_state_o\[74\]
+ sky130_fd_sc_hd__dfrtp_1
X_2379_ _0307_ _0308_ _0309_ _0310_ VGND VGND VPWR VPWR _0332_ sky130_fd_sc_hd__and4_1
X_5098_ clknet_leaf_12_clk_i i_mem_slice_stage.pre_data\[1\] net293 VGND VGND VPWR
+ VPWR i_mem_slice_stage.mem_state_o\[1\] sky130_fd_sc_hd__dfrtp_1
X_4118_ net62 net61 _1930_ VGND VGND VPWR VPWR _1934_ sky130_fd_sc_hd__or3b_1
X_4049_ _0665_ _0873_ VGND VGND VPWR VPWR _1867_ sky130_fd_sc_hd__nor2_1
XFILLER_0_66_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_93_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_78_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_448 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_66_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_74_492 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_61_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_6_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold8 i_exec_stage.exec_state_o\[33\] VGND VGND VPWR VPWR net345 sky130_fd_sc_hd__clkdlybuf4s25_1
XFILLER_0_69_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_25_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_37_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_4_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_25_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_52_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_52_164 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3420_ _1198_ _0911_ _0672_ _0417_ VGND VGND VPWR VPWR _1320_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_96_37 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3351_ _0594_ _1252_ _1253_ VGND VGND VPWR VPWR _1254_ sky130_fd_sc_hd__and3_1
XFILLER_0_0_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_489 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_702 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_713 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_724 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3282_ _0525_ _0545_ VGND VGND VPWR VPWR _1187_ sky130_fd_sc_hd__and2_1
XTAP_735 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_746 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_757 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_768 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5021_ clknet_leaf_39_clk_i i_decode_stage.decode_state_o\[147\] net282 VGND VGND
+ VPWR VPWR i_exec_stage.reg_meta_o\[0\] sky130_fd_sc_hd__dfrtp_1
XTAP_779 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_8_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4805_ i_exec_stage.data_fwd_o\[33\] i_decode_stage.decode_state_o\[147\] _1838_
+ VGND VGND VPWR VPWR _2325_ sky130_fd_sc_hd__mux2_1
XFILLER_0_61_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_16_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2997_ i_decode_stage.decode_state_o\[48\] _0339_ _0751_ i_decode_stage.decode_state_o\[132\]
+ VGND VGND VPWR VPWR _0909_ sky130_fd_sc_hd__a22o_1
XFILLER_0_90_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4736_ _2290_ VGND VGND VPWR VPWR _0263_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_9_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_186 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4667_ i_decode_stage.fetch_state_i\[24\] _1929_ _2123_ VGND VGND VPWR VPWR _0225_
+ sky130_fd_sc_hd__a21o_1
XFILLER_0_71_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3618_ _0966_ _0972_ _1508_ VGND VGND VPWR VPWR _1509_ sky130_fd_sc_hd__or3_1
XFILLER_0_101_225 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4598_ i_decode_stage.reg_meta_o\[70\] net85 _2207_ VGND VGND VPWR VPWR _2227_ sky130_fd_sc_hd__mux2_1
X_3549_ _0411_ _1428_ _1431_ _1443_ VGND VGND VPWR VPWR net135 sky130_fd_sc_hd__a211o_4
XFILLER_0_86_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5219_ clknet_leaf_31_clk_i _0218_ net286 VGND VGND VPWR VPWR i_decode_stage.fetch_state_i\[17\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_66_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_54_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_81_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_81_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_47_470 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_1_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_89_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2920_ _0324_ _0326_ net246 VGND VGND VPWR VPWR _0835_ sky130_fd_sc_hd__or3b_2
XFILLER_0_45_429 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2851_ _2336_ _2341_ net259 VGND VGND VPWR VPWR _0766_ sky130_fd_sc_hd__and3_1
XFILLER_0_72_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2782_ _0358_ _0698_ _0699_ _0700_ VGND VGND VPWR VPWR _0701_ sky130_fd_sc_hd__o31a_2
XFILLER_0_31_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4521_ i_decode_stage.reg_meta_o\[32\] net117 _2179_ VGND VGND VPWR VPWR _2188_ sky130_fd_sc_hd__mux2_1
XFILLER_0_53_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_25_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4452_ _0722_ _2150_ _2151_ VGND VGND VPWR VPWR _2152_ sky130_fd_sc_hd__and3_1
X_3403_ _1299_ _1301_ _1303_ VGND VGND VPWR VPWR _1304_ sky130_fd_sc_hd__or3_1
XFILLER_0_0_253 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4383_ net208 _2091_ VGND VGND VPWR VPWR _2096_ sky130_fd_sc_hd__nor2_1
X_3334_ _0660_ _0514_ VGND VGND VPWR VPWR _1237_ sky130_fd_sc_hd__or2_1
XTAP_510 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_521 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_532 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_543 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3265_ _0610_ _0642_ _0422_ VGND VGND VPWR VPWR _1170_ sky130_fd_sc_hd__mux2_1
XTAP_554 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_565 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_576 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5004_ clknet_leaf_2_clk_i _0184_ net283 VGND VGND VPWR VPWR i_decode_stage.reg_meta_o\[65\]
+ sky130_fd_sc_hd__dfrtp_1
XTAP_587 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_598 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3196_ i_decode_stage.decode_state_o\[0\] _0601_ VGND VGND VPWR VPWR _1106_ sky130_fd_sc_hd__nor2_2
XFILLER_0_48_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_48_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_72_94 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_36_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_48_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_16_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4719_ net214 i_decode_stage.fetch_state_i\[54\] _1927_ VGND VGND VPWR VPWR _2282_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_16_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_71_281 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_86_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_507 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3050_ i_decode_stage.decode_state_o\[57\] _0731_ _0733_ VGND VGND VPWR VPWR _0962_
+ sky130_fd_sc_hd__a21oi_1
XFILLER_0_89_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_77_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3952_ _0601_ _1804_ _1782_ _1800_ _1783_ VGND VGND VPWR VPWR net188 sky130_fd_sc_hd__a221o_1
X_3883_ _1035_ _1026_ _1027_ VGND VGND VPWR VPWR _1760_ sky130_fd_sc_hd__nand3_1
X_2903_ _0789_ _0790_ VGND VGND VPWR VPWR _0818_ sky130_fd_sc_hd__or2b_1
X_2834_ i_exec_stage.data_fwd_o\[28\] _0726_ _0748_ VGND VGND VPWR VPWR _0749_ sky130_fd_sc_hd__o21ai_4
X_2765_ _0677_ _0683_ _0345_ VGND VGND VPWR VPWR _0684_ sky130_fd_sc_hd__mux2_1
X_4504_ _0722_ VGND VGND VPWR VPWR _2179_ sky130_fd_sc_hd__buf_12
XFILLER_0_53_281 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2696_ _0451_ _0620_ _0621_ _0492_ VGND VGND VPWR VPWR _0622_ sky130_fd_sc_hd__a2bb2o_4
X_4435_ _2042_ _2137_ VGND VGND VPWR VPWR _2138_ sky130_fd_sc_hd__or2_1
XFILLER_0_41_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4366_ _2081_ _2082_ VGND VGND VPWR VPWR _2083_ sky130_fd_sc_hd__nor2_1
X_3317_ _0662_ _1095_ _0590_ VGND VGND VPWR VPWR _1221_ sky130_fd_sc_hd__o21ai_1
XTAP_351 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_340 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_384 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_373 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_362 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4297_ _2032_ _2019_ VGND VGND VPWR VPWR _2033_ sky130_fd_sc_hd__nor2_1
X_3248_ _0662_ _1153_ VGND VGND VPWR VPWR _1154_ sky130_fd_sc_hd__or2_1
XTAP_395 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3179_ _0678_ _0682_ VGND VGND VPWR VPWR _1091_ sky130_fd_sc_hd__and2_1
XPHY_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_76_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_8_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_473 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_32_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_4_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_86_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_67_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_35_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2550_ _0346_ i_decode_stage.decode_state_o\[234\] VGND VGND VPWR VPWR _0493_ sky130_fd_sc_hd__nand2_2
X_2481_ _0428_ _0405_ _0430_ VGND VGND VPWR VPWR _0431_ sky130_fd_sc_hd__a21oi_1
X_4220_ i_decode_stage.decode_state_o\[53\] i_decode_stage.fetch_state_i\[45\] _1982_
+ VGND VGND VPWR VPWR _1989_ sky130_fd_sc_hd__mux2_1
X_4151_ _1953_ VGND VGND VPWR VPWR _0015_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_37_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_49_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3102_ _0556_ _0743_ VGND VGND VPWR VPWR _1014_ sky130_fd_sc_hd__nor2_2
XFILLER_0_37_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4082_ _0535_ _1020_ _0730_ _0530_ VGND VGND VPWR VPWR _1900_ sky130_fd_sc_hd__o22ai_1
X_3033_ _0346_ i_decode_stage.decode_state_o\[133\] _0347_ _0649_ VGND VGND VPWR VPWR
+ _0945_ sky130_fd_sc_hd__a22o_1
X_4984_ clknet_leaf_44_clk_i _0164_ net281 VGND VGND VPWR VPWR i_decode_stage.reg_meta_o\[45\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_53_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3935_ _0794_ VGND VGND VPWR VPWR _1795_ sky130_fd_sc_hd__inv_1
X_3866_ _1025_ _1743_ VGND VGND VPWR VPWR _1744_ sky130_fd_sc_hd__xor2_1
X_3797_ _0344_ _0568_ _1069_ VGND VGND VPWR VPWR _1679_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_14_421 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2817_ i_decode_stage.decode_state_o\[100\] VGND VGND VPWR VPWR _0732_ sky130_fd_sc_hd__inv_2
X_2748_ _0376_ _0377_ _0378_ i_decode_stage.reg_meta_o\[52\] VGND VGND VPWR VPWR _0669_
+ sky130_fd_sc_hd__o31a_1
X_4418_ _2042_ _2123_ VGND VGND VPWR VPWR _2124_ sky130_fd_sc_hd__or2_1
X_2679_ i_decode_stage.decode_state_o\[118\] _0493_ VGND VGND VPWR VPWR _0607_ sky130_fd_sc_hd__nand2_1
X_4349_ net231 _1840_ VGND VGND VPWR VPWR _2070_ sky130_fd_sc_hd__or2_1
XFILLER_0_96_457 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_83_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_52_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_32_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_32_273 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_20_457 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_74_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_99_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3720_ _1412_ _1458_ _1605_ _1281_ _0448_ VGND VGND VPWR VPWR _1606_ sky130_fd_sc_hd__a221o_1
XFILLER_0_7_429 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_55_321 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_67_181 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_43_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3651_ _1537_ _1540_ _0523_ VGND VGND VPWR VPWR _1541_ sky130_fd_sc_hd__mux2_1
X_3582_ _1390_ _1474_ _0660_ VGND VGND VPWR VPWR _1475_ sky130_fd_sc_hd__mux2_1
X_2602_ _0527_ _0538_ VGND VGND VPWR VPWR _0539_ sky130_fd_sc_hd__or2_1
X_2533_ _0451_ _0475_ _0477_ VGND VGND VPWR VPWR _0478_ sky130_fd_sc_hd__o21ai_4
X_2464_ i_decode_stage.decode_state_o\[237\] _0413_ VGND VGND VPWR VPWR _0414_ sky130_fd_sc_hd__or2_1
X_5252_ clknet_leaf_32_clk_i _0251_ net287 VGND VGND VPWR VPWR i_decode_stage.fetch_state_i\[50\]
+ sky130_fd_sc_hd__dfrtp_1
X_4203_ i_decode_stage.decode_state_o\[45\] i_decode_stage.fetch_state_i\[37\] _1840_
+ VGND VGND VPWR VPWR _1980_ sky130_fd_sc_hd__mux2_1
X_5183_ clknet_leaf_32_clk_i net405 net286 VGND VGND VPWR VPWR i_mem_slice_stage.mem_state_o\[90\]
+ sky130_fd_sc_hd__dfrtp_1
X_2395_ i_exec_stage.data_fwd_o\[36\] VGND VGND VPWR VPWR _0348_ sky130_fd_sc_hd__inv_2
XFILLER_0_48_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4134_ i_decode_stage.fetch_state_i\[3\] i_decode_stage.decode_state_o\[11\] _1936_
+ VGND VGND VPWR VPWR _1945_ sky130_fd_sc_hd__mux2_1
X_4065_ _0615_ _1785_ VGND VGND VPWR VPWR _1883_ sky130_fd_sc_hd__nor2_1
X_3016_ _0633_ _0927_ VGND VGND VPWR VPWR _0928_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_93_405 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_93_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_46_321 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4967_ clknet_leaf_10_clk_i _0147_ net292 VGND VGND VPWR VPWR i_decode_stage.reg_meta_o\[28\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_58_181 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3918_ _0846_ _0847_ VGND VGND VPWR VPWR _1785_ sky130_fd_sc_hd__and2_2
X_4898_ clknet_leaf_23_clk_i _0078_ net296 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[232\]
+ sky130_fd_sc_hd__dfrtp_4
XFILLER_0_61_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3849_ _0738_ _1727_ VGND VGND VPWR VPWR _1728_ sky130_fd_sc_hd__or2_1
Xclkbuf_leaf_0_clk_i clknet_2_0__leaf_clk_i VGND VGND VPWR VPWR clknet_leaf_0_clk_i
+ sky130_fd_sc_hd__clkbuf_16
XTAP_1122 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1111 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1100 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_1133 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_56_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_37_321 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_25_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_917 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_906 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_265 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_939 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_928 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_87_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_405 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4821_ clknet_leaf_25_clk_i _0001_ net289 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[3\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_7_237 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4752_ _2298_ VGND VGND VPWR VPWR _0271_ sky130_fd_sc_hd__clkbuf_1
X_3703_ _0448_ _1254_ _1589_ _1501_ _1242_ VGND VGND VPWR VPWR _1590_ sky130_fd_sc_hd__o32a_1
X_4683_ net226 i_decode_stage.fetch_state_i\[36\] _1967_ VGND VGND VPWR VPWR _2264_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_43_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3634_ _0411_ _1509_ _1510_ _1524_ VGND VGND VPWR VPWR net139 sky130_fd_sc_hd__a31o_4
X_3565_ _1285_ _1458_ _0590_ VGND VGND VPWR VPWR _1459_ sky130_fd_sc_hd__mux2_1
X_3496_ _1194_ _1326_ _1392_ _1041_ VGND VGND VPWR VPWR _1393_ sky130_fd_sc_hd__o22a_1
X_5304_ clknet_leaf_34_clk_i _0303_ VGND VGND VPWR VPWR i_exec_stage.data_fwd_o\[38\]
+ sky130_fd_sc_hd__dfxtp_1
X_2516_ _0346_ i_decode_stage.decode_state_o\[127\] VGND VGND VPWR VPWR _0463_ sky130_fd_sc_hd__or2b_1
XFILLER_0_59_95 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2447_ _0364_ _0365_ _0366_ _0367_ VGND VGND VPWR VPWR _0397_ sky130_fd_sc_hd__nand4_1
XFILLER_0_11_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5235_ clknet_leaf_33_clk_i _0234_ net287 VGND VGND VPWR VPWR i_decode_stage.fetch_state_i\[1\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_75_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5166_ clknet_leaf_41_clk_i net379 net280 VGND VGND VPWR VPWR i_mem_slice_stage.mem_state_o\[73\]
+ sky130_fd_sc_hd__dfrtp_1
X_2378_ _0324_ _0326_ net242 VGND VGND VPWR VPWR _0331_ sky130_fd_sc_hd__or3_1
X_5097_ clknet_leaf_13_clk_i i_mem_slice_stage.pre_data\[0\] net293 VGND VGND VPWR
+ VPWR i_mem_slice_stage.mem_state_o\[0\] sky130_fd_sc_hd__dfrtp_1
X_4117_ i_decode_stage.decode_state_o\[3\] _1929_ _1933_ VGND VGND VPWR VPWR _0001_
+ sky130_fd_sc_hd__a21o_1
X_4048_ _1861_ _1863_ _1864_ _1865_ VGND VGND VPWR VPWR _1866_ sky130_fd_sc_hd__o31a_1
XFILLER_0_93_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_81_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold9 i_exec_stage.exec_state_o\[67\] VGND VGND VPWR VPWR net346 sky130_fd_sc_hd__clkdlybuf4s25_1
XFILLER_0_84_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_52_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_96_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3350_ _0662_ _0587_ _0707_ VGND VGND VPWR VPWR _1253_ sky130_fd_sc_hd__o21ai_1
XTAP_703 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_714 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_725 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3281_ _1129_ _1185_ _0594_ VGND VGND VPWR VPWR _1186_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_29_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5020_ clknet_leaf_20_clk_i _0200_ net296 VGND VGND VPWR VPWR i_decode_stage.reg_meta_o\[81\]
+ sky130_fd_sc_hd__dfrtp_4
XTAP_736 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_747 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_758 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_769 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_31_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_48_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_61_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_0_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4804_ _2324_ VGND VGND VPWR VPWR _0297_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_63_419 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_90_238 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2996_ _0386_ _0905_ _0906_ _0907_ VGND VGND VPWR VPWR _0908_ sky130_fd_sc_hd__o31ai_4
X_4735_ net223 i_decode_stage.fetch_state_i\[62\] _1927_ VGND VGND VPWR VPWR _2290_
+ sky130_fd_sc_hd__mux2_1
X_4666_ _2259_ VGND VGND VPWR VPWR _0224_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_43_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_71_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4597_ _2226_ VGND VGND VPWR VPWR _0188_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_43_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3617_ _1488_ _1491_ _0975_ VGND VGND VPWR VPWR _1508_ sky130_fd_sc_hd__o21a_1
XFILLER_0_101_237 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_3_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3548_ _1129_ _1436_ _1439_ _0842_ _1442_ VGND VGND VPWR VPWR _1443_ sky130_fd_sc_hd__a221o_1
X_3479_ _0946_ _1347_ _0935_ VGND VGND VPWR VPWR _1377_ sky130_fd_sc_hd__a21oi_1
X_5218_ clknet_leaf_31_clk_i _0217_ net286 VGND VGND VPWR VPWR i_decode_stage.fetch_state_i\[16\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_98_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5149_ clknet_leaf_11_clk_i net374 net297 VGND VGND VPWR VPWR i_mem_slice_stage.mem_state_o\[56\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_66_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_482 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_leaf_33_clk_i clknet_2_1__leaf_clk_i VGND VGND VPWR VPWR clknet_leaf_33_clk_i
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_30_393 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_85_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_97_393 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2850_ _0756_ _0764_ VGND VGND VPWR VPWR _0765_ sky130_fd_sc_hd__or2_1
XFILLER_0_5_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_38_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_72_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2781_ i_exec_stage.data_fwd_o\[3\] _0352_ _0355_ _0357_ VGND VGND VPWR VPWR _0700_
+ sky130_fd_sc_hd__or4_1
XFILLER_0_31_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4520_ _2187_ VGND VGND VPWR VPWR _0150_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_80_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_13_349 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4451_ net223 _2145_ VGND VGND VPWR VPWR _2151_ sky130_fd_sc_hd__nand2_1
X_3402_ _0660_ _1173_ _1302_ VGND VGND VPWR VPWR _1303_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_0_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4382_ net208 _2091_ VGND VGND VPWR VPWR _2095_ sky130_fd_sc_hd__and2_1
XTAP_500 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_265 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_21_393 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_511 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_522 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_533 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3333_ _0898_ _1212_ _1233_ _1235_ VGND VGND VPWR VPWR _1236_ sky130_fd_sc_hd__o31a_1
X_3264_ _0624_ _0513_ _0527_ VGND VGND VPWR VPWR _1169_ sky130_fd_sc_hd__mux2_1
XTAP_544 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_555 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_566 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5003_ clknet_leaf_1_clk_i _0183_ net283 VGND VGND VPWR VPWR i_decode_stage.reg_meta_o\[64\]
+ sky130_fd_sc_hd__dfrtp_1
XTAP_577 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_588 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_599 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3195_ i_exec_stage.alu_out\[1\] i_exec_stage.alu_out\[0\] _1105_ VGND VGND VPWR
+ VPWR net162 sky130_fd_sc_hd__nor3_1
XFILLER_0_88_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_76_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_48_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_91_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2979_ _0525_ _0703_ VGND VGND VPWR VPWR _0891_ sky130_fd_sc_hd__nor2_1
XFILLER_0_8_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4718_ _2281_ VGND VGND VPWR VPWR _0254_ sky130_fd_sc_hd__clkbuf_1
X_4649_ i_decode_stage.fetch_state_i\[14\] _2087_ _2234_ VGND VGND VPWR VPWR _2252_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_71_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_12_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_94_374 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_54_238 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_50_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_22_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_50_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_50_488 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_89_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3951_ _0730_ VGND VGND VPWR VPWR _1804_ sky130_fd_sc_hd__inv_2
XFILLER_0_42_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2902_ _0815_ _0816_ VGND VGND VPWR VPWR _0817_ sky130_fd_sc_hd__nand2b_2
XFILLER_0_85_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3882_ _1035_ _1758_ VGND VGND VPWR VPWR _1759_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_45_205 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_26_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2833_ i_decode_stage.reg_meta_o\[33\] _0727_ _0386_ _0747_ VGND VGND VPWR VPWR _0748_
+ sky130_fd_sc_hd__a211o_1
X_2764_ _0347_ _0678_ _0682_ i_decode_stage.decode_state_o\[129\] _0346_ VGND VGND
+ VPWR VPWR _0683_ sky130_fd_sc_hd__a32oi_4
XFILLER_0_13_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4503_ _2178_ VGND VGND VPWR VPWR _0142_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_53_293 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2695_ i_decode_stage.decode_state_o\[120\] _0493_ VGND VGND VPWR VPWR _0621_ sky130_fd_sc_hd__nand2_1
X_4434_ net219 _2131_ _2136_ VGND VGND VPWR VPWR _2137_ sky130_fd_sc_hd__o21a_1
X_4365_ net203 _2075_ net204 VGND VGND VPWR VPWR _2082_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_6_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3316_ _0660_ _1084_ VGND VGND VPWR VPWR _1220_ sky130_fd_sc_hd__nor2_1
XTAP_341 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_330 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_385 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_374 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_363 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_352 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4296_ net61 VGND VGND VPWR VPWR _2032_ sky130_fd_sc_hd__inv_2
X_3247_ _1042_ _1152_ _0394_ VGND VGND VPWR VPWR _1153_ sky130_fd_sc_hd__mux2_1
XTAP_396 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3178_ _0344_ _0677_ _1089_ VGND VGND VPWR VPWR _1090_ sky130_fd_sc_hd__a21o_1
XPHY_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_91_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_91_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_76_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_485 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_32_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_82_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_23_433 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2480_ i_decode_stage.decode_state_o\[239\] _0429_ VGND VGND VPWR VPWR _0430_ sky130_fd_sc_hd__nand2_8
X_4150_ i_decode_stage.fetch_state_i\[11\] i_decode_stage.decode_state_o\[19\] _1936_
+ VGND VGND VPWR VPWR _1953_ sky130_fd_sc_hd__mux2_1
X_3101_ _0736_ _0737_ VGND VGND VPWR VPWR _1013_ sky130_fd_sc_hd__nor2_1
X_4081_ _0561_ _0768_ _0776_ _0468_ VGND VGND VPWR VPWR _1899_ sky130_fd_sc_hd__a22o_1
X_3032_ _0672_ _0910_ VGND VGND VPWR VPWR _0944_ sky130_fd_sc_hd__and2b_1
X_4983_ clknet_leaf_44_clk_i _0163_ net281 VGND VGND VPWR VPWR i_decode_stage.reg_meta_o\[44\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_58_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3934_ _1794_ VGND VGND VPWR VPWR net180 sky130_fd_sc_hd__clkbuf_1
X_3865_ _1013_ _1016_ _1710_ _1742_ VGND VGND VPWR VPWR _1743_ sky130_fd_sc_hd__a31o_1
XFILLER_0_85_182 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2816_ _0339_ VGND VGND VPWR VPWR _0731_ sky130_fd_sc_hd__buf_4
X_3796_ _1421_ _1374_ _1129_ VGND VGND VPWR VPWR _1678_ sky130_fd_sc_hd__a21oi_1
X_2747_ _0363_ _0369_ _0374_ net272 VGND VGND VPWR VPWR _0668_ sky130_fd_sc_hd__and4_1
XFILLER_0_14_433 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_75_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_14_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2678_ i_exec_stage.data_fwd_o\[15\] _0605_ _0460_ VGND VGND VPWR VPWR _0606_ sky130_fd_sc_hd__mux2_1
XFILLER_0_78_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4417_ net216 _2117_ _2122_ VGND VGND VPWR VPWR _2123_ sky130_fd_sc_hd__o21a_1
XFILLER_0_1_393 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4348_ net231 _2065_ VGND VGND VPWR VPWR _2069_ sky130_fd_sc_hd__xor2_1
X_4279_ net59 net62 net60 _1937_ VGND VGND VPWR VPWR _2019_ sky130_fd_sc_hd__or4bb_2
XFILLER_0_94_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_96_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_91_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_20_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_55_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_67_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3650_ _0421_ _1538_ _1539_ VGND VGND VPWR VPWR _1540_ sky130_fd_sc_hd__a21o_1
X_3581_ _1473_ VGND VGND VPWR VPWR _1474_ sky130_fd_sc_hd__inv_1
X_2601_ _0532_ _0537_ _0465_ VGND VGND VPWR VPWR _0538_ sky130_fd_sc_hd__mux2_1
XFILLER_0_70_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2532_ _0476_ _0346_ _0462_ VGND VGND VPWR VPWR _0477_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_11_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5251_ clknet_leaf_32_clk_i _0250_ net286 VGND VGND VPWR VPWR i_decode_stage.fetch_state_i\[49\]
+ sky130_fd_sc_hd__dfrtp_1
X_2463_ _0412_ VGND VGND VPWR VPWR _0413_ sky130_fd_sc_hd__buf_8
X_4202_ _1979_ VGND VGND VPWR VPWR _0040_ sky130_fd_sc_hd__clkbuf_1
X_5182_ clknet_leaf_33_clk_i net388 net288 VGND VGND VPWR VPWR i_mem_slice_stage.mem_state_o\[89\]
+ sky130_fd_sc_hd__dfrtp_1
X_2394_ _0346_ i_decode_stage.decode_state_o\[234\] VGND VGND VPWR VPWR _0347_ sky130_fd_sc_hd__nor2_8
X_4133_ _1944_ VGND VGND VPWR VPWR _0006_ sky130_fd_sc_hd__clkbuf_1
X_4064_ _1877_ _1881_ _1872_ VGND VGND VPWR VPWR _1882_ sky130_fd_sc_hd__a21oi_1
X_3015_ _2333_ _0925_ _0926_ VGND VGND VPWR VPWR _0927_ sky130_fd_sc_hd__a21oi_4
XFILLER_0_93_417 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_19_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4966_ clknet_leaf_3_clk_i _0146_ net284 VGND VGND VPWR VPWR i_decode_stage.reg_meta_o\[27\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_58_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3917_ _0855_ _1106_ _1784_ VGND VGND VPWR VPWR net172 sky130_fd_sc_hd__o21ai_1
XFILLER_0_46_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4897_ clknet_leaf_18_clk_i _0077_ net296 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[100\]
+ sky130_fd_sc_hd__dfrtp_4
X_3848_ _1016_ _1710_ _1014_ VGND VGND VPWR VPWR _1727_ sky130_fd_sc_hd__a21oi_1
X_3779_ _1624_ _1661_ _0422_ VGND VGND VPWR VPWR _1662_ sky130_fd_sc_hd__mux2_1
XTAP_1123 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1112 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1101 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1134 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_428 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_56_119 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_37_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_52_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_100_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_100_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_907 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_929 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_918 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_18_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4820_ clknet_leaf_34_clk_i _0000_ VGND VGND VPWR VPWR i_decode_stage.valid_o sky130_fd_sc_hd__dfxtp_2
XFILLER_0_83_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4751_ i_exec_stage.data_fwd_o\[6\] net157 _1839_ VGND VGND VPWR VPWR _2298_ sky130_fd_sc_hd__mux2_1
XFILLER_0_50_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3702_ _1326_ _1434_ _1588_ _1041_ VGND VGND VPWR VPWR _1589_ sky130_fd_sc_hd__o22ai_1
X_4682_ _2263_ VGND VGND VPWR VPWR _0236_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_7_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_50_43 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_55_185 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_31_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3633_ _0430_ _1512_ _1523_ VGND VGND VPWR VPWR _1524_ sky130_fd_sc_hd__o21ai_1
X_3564_ _1371_ _1457_ _0523_ VGND VGND VPWR VPWR _1458_ sky130_fd_sc_hd__mux2_1
X_3495_ _0660_ _1297_ _1391_ VGND VGND VPWR VPWR _1392_ sky130_fd_sc_hd__o21ai_1
X_5303_ clknet_leaf_38_clk_i _0302_ VGND VGND VPWR VPWR i_exec_stage.data_fwd_o\[37\]
+ sky130_fd_sc_hd__dfxtp_1
X_2515_ _0346_ i_decode_stage.decode_state_o\[100\] _0347_ VGND VGND VPWR VPWR _0462_
+ sky130_fd_sc_hd__a21oi_4
X_2446_ _0359_ _0360_ _0361_ VGND VGND VPWR VPWR _0396_ sky130_fd_sc_hd__nand3_1
X_5234_ clknet_leaf_24_clk_i _0233_ net287 VGND VGND VPWR VPWR i_decode_stage.fetch_state_i\[0\]
+ sky130_fd_sc_hd__dfrtp_1
X_5165_ clknet_leaf_33_clk_i net338 net284 VGND VGND VPWR VPWR i_mem_slice_stage.mem_state_o\[72\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_75_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2377_ i_mem_slice_stage.mem_state_o\[71\] _0328_ _0329_ _0330_ VGND VGND VPWR VPWR
+ net242 sky130_fd_sc_hd__a22o_2
X_4116_ net62 net60 _0722_ _1932_ VGND VGND VPWR VPWR _1933_ sky130_fd_sc_hd__and4bb_1
X_5096_ clknet_leaf_36_clk_i i_exec_stage.valid net284 VGND VGND VPWR VPWR i_exec_stage.valid_o
+ sky130_fd_sc_hd__dfrtp_1
X_4047_ _0665_ _0873_ net195 _1862_ VGND VGND VPWR VPWR _1865_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_93_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4949_ clknet_leaf_2_clk_i _0129_ net283 VGND VGND VPWR VPWR i_decode_stage.reg_meta_o\[10\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_46_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_22_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_89_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_69_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_69_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_52_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3280_ _0590_ _1180_ _1184_ VGND VGND VPWR VPWR _1185_ sky130_fd_sc_hd__o21a_1
XTAP_704 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_715 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_726 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_737 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_748 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_759 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_45_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_45_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_75_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4803_ i_exec_stage.data_fwd_o\[32\] net154 _1838_ VGND VGND VPWR VPWR _2324_ sky130_fd_sc_hd__mux2_1
X_2995_ i_exec_stage.data_fwd_o\[9\] _0311_ _0316_ _0320_ VGND VGND VPWR VPWR _0907_
+ sky130_fd_sc_hd__or4_1
X_4734_ _2289_ VGND VGND VPWR VPWR _0262_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_56_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_43_144 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_71_420 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4665_ i_decode_stage.fetch_state_i\[23\] _2118_ _2234_ VGND VGND VPWR VPWR _2259_
+ sky130_fd_sc_hd__mux2_1
X_4596_ i_decode_stage.reg_meta_o\[69\] net84 _2207_ VGND VGND VPWR VPWR _2226_ sky130_fd_sc_hd__mux2_1
X_3616_ _0411_ _1493_ _1495_ _1507_ VGND VGND VPWR VPWR net138 sky130_fd_sc_hd__a211o_4
XFILLER_0_101_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3547_ _1129_ _1441_ VGND VGND VPWR VPWR _1442_ sky130_fd_sc_hd__nor2_1
XFILLER_0_101_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_86_61 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3478_ _1369_ _1375_ _1129_ VGND VGND VPWR VPWR _1376_ sky130_fd_sc_hd__mux2_1
X_5217_ clknet_leaf_31_clk_i _0216_ net286 VGND VGND VPWR VPWR i_decode_stage.fetch_state_i\[15\]
+ sky130_fd_sc_hd__dfrtp_1
X_2429_ _0358_ _0375_ _0379_ _0380_ VGND VGND VPWR VPWR _0381_ sky130_fd_sc_hd__o31a_2
X_5148_ clknet_leaf_11_clk_i net394 net297 VGND VGND VPWR VPWR i_mem_slice_stage.mem_state_o\[55\]
+ sky130_fd_sc_hd__dfrtp_1
X_5079_ clknet_leaf_31_clk_i i_decode_stage.decode_state_o\[23\] net286 VGND VGND
+ VPWR VPWR i_exec_stage.exec_state_o\[54\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_94_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_22_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_15_79 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_57_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_72_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2780_ _0376_ _0377_ _0378_ i_decode_stage.reg_meta_o\[46\] VGND VGND VPWR VPWR _0699_
+ sky130_fd_sc_hd__o31a_1
XFILLER_0_25_122 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_25_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4450_ net223 _2145_ VGND VGND VPWR VPWR _2150_ sky130_fd_sc_hd__or2_1
X_3401_ _0662_ _1170_ _1088_ VGND VGND VPWR VPWR _1302_ sky130_fd_sc_hd__a21o_1
X_4381_ net138 _2047_ _2048_ _2093_ _2094_ VGND VGND VPWR VPWR _0104_ sky130_fd_sc_hd__o221a_1
X_3332_ _0430_ _1234_ VGND VGND VPWR VPWR _1235_ sky130_fd_sc_hd__nor2_1
XFILLER_0_21_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_0_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_501 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_512 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_523 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_534 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3263_ _1164_ _1167_ VGND VGND VPWR VPWR _1168_ sky130_fd_sc_hd__xnor2_1
XTAP_545 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_556 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_567 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_5002_ clknet_leaf_0_clk_i _0182_ net281 VGND VGND VPWR VPWR i_decode_stage.reg_meta_o\[63\]
+ sky130_fd_sc_hd__dfrtp_1
XTAP_578 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_589 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_56_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3194_ i_decode_stage.decode_state_o\[0\] _0601_ net199 VGND VGND VPWR VPWR _1105_
+ sky130_fd_sc_hd__a21bo_1
X_2978_ _0525_ _0703_ VGND VGND VPWR VPWR _0890_ sky130_fd_sc_hd__and2_1
XFILLER_0_44_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4717_ net213 i_decode_stage.fetch_state_i\[53\] _1927_ VGND VGND VPWR VPWR _2281_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_44_464 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4648_ _2251_ VGND VGND VPWR VPWR _0214_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_44_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_31_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4579_ _2217_ VGND VGND VPWR VPWR _0179_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_86_309 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_79_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_94_386 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_35_420 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3950_ _0601_ _1803_ _1780_ _1800_ _1781_ VGND VGND VPWR VPWR net187 sky130_fd_sc_hd__a221o_1
X_2901_ _0500_ _0814_ VGND VGND VPWR VPWR _0816_ sky130_fd_sc_hd__nand2_1
X_3881_ _1025_ _1743_ _1023_ VGND VGND VPWR VPWR _1758_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_45_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2832_ _2336_ _2341_ net261 VGND VGND VPWR VPWR _0747_ sky130_fd_sc_hd__and3_1
X_2763_ _0358_ _0680_ _0681_ VGND VGND VPWR VPWR _0682_ sky130_fd_sc_hd__or3_4
X_4502_ i_decode_stage.reg_meta_o\[23\] net107 _2012_ VGND VGND VPWR VPWR _2178_ sky130_fd_sc_hd__mux2_1
X_2694_ i_exec_stage.data_fwd_o\[17\] _0619_ _0460_ VGND VGND VPWR VPWR _0620_ sky130_fd_sc_hd__mux2_2
XFILLER_0_13_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4433_ net219 _2131_ _1926_ VGND VGND VPWR VPWR _2136_ sky130_fd_sc_hd__a21oi_1
X_4364_ net203 net204 _2075_ VGND VGND VPWR VPWR _2081_ sky130_fd_sc_hd__and3_1
X_3315_ _0707_ _1218_ _1217_ _1187_ VGND VGND VPWR VPWR _1219_ sky130_fd_sc_hd__o22a_1
XTAP_342 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_331 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_320 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4295_ net62 net60 _1930_ VGND VGND VPWR VPWR _2031_ sky130_fd_sc_hd__and3b_1
X_3246_ _0404_ _0893_ _0343_ VGND VGND VPWR VPWR _1152_ sky130_fd_sc_hd__mux2_1
XTAP_375 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_364 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_353 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_386 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_397 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3177_ _0465_ _0666_ VGND VGND VPWR VPWR _1089_ sky130_fd_sc_hd__and2_1
Xclkbuf_leaf_32_clk_i clknet_2_1__leaf_clk_i VGND VGND VPWR VPWR clknet_leaf_32_clk_i
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_68_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_91_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_17_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_32_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_94_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_12_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_23_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_50_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3100_ _0551_ _1005_ _0765_ _1008_ _1011_ VGND VGND VPWR VPWR _1012_ sky130_fd_sc_hd__o221a_1
XFILLER_0_37_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4080_ _0549_ _0749_ _0759_ _0566_ VGND VGND VPWR VPWR _1898_ sky130_fd_sc_hd__a22o_1
X_3031_ _0858_ _0941_ _0942_ VGND VGND VPWR VPWR _0943_ sky130_fd_sc_hd__a21o_1
XFILLER_0_53_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4982_ clknet_leaf_26_clk_i _0162_ net289 VGND VGND VPWR VPWR i_decode_stage.reg_meta_o\[43\]
+ sky130_fd_sc_hd__dfrtp_4
X_3933_ _1793_ net194 _1110_ VGND VGND VPWR VPWR _1794_ sky130_fd_sc_hd__mux2_1
X_3864_ _0736_ _1014_ _0737_ VGND VGND VPWR VPWR _1742_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_85_194 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2815_ i_exec_stage.data_fwd_o\[30\] _0726_ _0729_ VGND VGND VPWR VPWR _0730_ sky130_fd_sc_hd__o21ai_4
XFILLER_0_73_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3795_ _0430_ _1675_ _1676_ VGND VGND VPWR VPWR _1677_ sky130_fd_sc_hd__or3_1
XFILLER_0_14_445 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2746_ i_mem_slice_stage.mem_state_o\[79\] _0328_ _0667_ _0330_ VGND VGND VPWR VPWR
+ net272 sky130_fd_sc_hd__a22o_1
XFILLER_0_14_489 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2677_ net247 i_decode_stage.reg_meta_o\[58\] _0457_ VGND VGND VPWR VPWR _0605_ sky130_fd_sc_hd__mux2_1
XFILLER_0_1_361 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4416_ net216 _2117_ _1926_ VGND VGND VPWR VPWR _2122_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_41_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_68_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4347_ net160 _2047_ _2048_ _2067_ _2068_ VGND VGND VPWR VPWR _0096_ sky130_fd_sc_hd__o221a_1
X_4278_ _2018_ VGND VGND VPWR VPWR _0077_ sky130_fd_sc_hd__clkbuf_1
X_3229_ _0540_ _1083_ VGND VGND VPWR VPWR _1135_ sky130_fd_sc_hd__nor2_1
XFILLER_0_94_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_96_404 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_76_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_76_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_9_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_24_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_91_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_87_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_55_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_23_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_99_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_55_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3580_ _1432_ _1472_ _0421_ VGND VGND VPWR VPWR _1473_ sky130_fd_sc_hd__mux2_1
X_2600_ _0451_ _0535_ _0462_ _0536_ VGND VGND VPWR VPWR _0537_ sky130_fd_sc_hd__a2bb2o_4
X_2531_ i_decode_stage.decode_state_o\[125\] VGND VGND VPWR VPWR _0476_ sky130_fd_sc_hd__inv_2
X_5250_ clknet_leaf_29_clk_i _0249_ net291 VGND VGND VPWR VPWR i_decode_stage.fetch_state_i\[48\]
+ sky130_fd_sc_hd__dfrtp_1
X_2462_ i_decode_stage.decode_state_o\[236\] i_decode_stage.decode_state_o\[239\]
+ i_decode_stage.decode_state_o\[238\] VGND VGND VPWR VPWR _0412_ sky130_fd_sc_hd__or3b_1
X_4201_ i_decode_stage.decode_state_o\[44\] i_decode_stage.fetch_state_i\[36\] _1840_
+ VGND VGND VPWR VPWR _1979_ sky130_fd_sc_hd__mux2_1
X_5181_ clknet_leaf_32_clk_i net351 net287 VGND VGND VPWR VPWR i_mem_slice_stage.mem_state_o\[88\]
+ sky130_fd_sc_hd__dfrtp_1
X_2393_ i_decode_stage.decode_state_o\[235\] VGND VGND VPWR VPWR _0346_ sky130_fd_sc_hd__buf_12
X_4132_ i_decode_stage.fetch_state_i\[2\] i_decode_stage.decode_state_o\[10\] _1936_
+ VGND VGND VPWR VPWR _1944_ sky130_fd_sc_hd__mux2_1
XFILLER_0_48_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4063_ _1870_ _1875_ _1874_ _1880_ VGND VGND VPWR VPWR _1881_ sky130_fd_sc_hd__a211o_1
X_3014_ i_decode_stage.decode_state_o\[51\] _0731_ _0733_ VGND VGND VPWR VPWR _0926_
+ sky130_fd_sc_hd__a21oi_2
XFILLER_0_93_429 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4965_ clknet_leaf_3_clk_i _0145_ net284 VGND VGND VPWR VPWR i_decode_stage.reg_meta_o\[26\]
+ sky130_fd_sc_hd__dfrtp_1
X_3916_ net195 _1106_ VGND VGND VPWR VPWR _1784_ sky130_fd_sc_hd__nand2_1
XFILLER_0_34_507 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4896_ clknet_leaf_18_clk_i _0076_ net296 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[134\]
+ sky130_fd_sc_hd__dfrtp_4
X_3847_ _0411_ _1711_ _1712_ _1726_ VGND VGND VPWR VPWR net150 sky130_fd_sc_hd__a31o_4
X_3778_ _0345_ _0563_ _0471_ VGND VGND VPWR VPWR _1661_ sky130_fd_sc_hd__a21o_1
XFILLER_0_6_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2729_ _0363_ _0369_ _0374_ net243 VGND VGND VPWR VPWR _0652_ sky130_fd_sc_hd__and4_1
XFILLER_0_14_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_14_275 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_69_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_1113 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1102 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1135 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1124 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_52_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_60_392 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_908 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_919 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_18_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_87_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4750_ _2297_ VGND VGND VPWR VPWR _0270_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_55_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3701_ _1518_ _1587_ _0660_ VGND VGND VPWR VPWR _1588_ sky130_fd_sc_hd__mux2_1
XFILLER_0_83_473 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4681_ net225 i_decode_stage.fetch_state_i\[35\] _1967_ VGND VGND VPWR VPWR _2263_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_50_55 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3632_ _0591_ _1477_ _1513_ _1516_ _1522_ VGND VGND VPWR VPWR _1523_ sky130_fd_sc_hd__o2111a_1
XFILLER_0_43_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_55_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3563_ _1413_ _1456_ _0394_ VGND VGND VPWR VPWR _1457_ sky130_fd_sc_hd__mux2_1
X_5302_ clknet_leaf_36_clk_i _0301_ VGND VGND VPWR VPWR i_exec_stage.data_fwd_o\[36\]
+ sky130_fd_sc_hd__dfxtp_1
X_3494_ _0525_ _1390_ VGND VGND VPWR VPWR _1391_ sky130_fd_sc_hd__or2_1
X_2514_ i_exec_stage.data_fwd_o\[24\] _0458_ _0460_ VGND VGND VPWR VPWR _0461_ sky130_fd_sc_hd__mux2_1
XFILLER_0_11_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2445_ _0363_ _0369_ _0374_ i_decode_stage.reg_meta_o\[45\] VGND VGND VPWR VPWR _0395_
+ sky130_fd_sc_hd__a31oi_2
X_5233_ clknet_leaf_24_clk_i _0232_ net287 VGND VGND VPWR VPWR i_decode_stage.fetch_state_i\[31\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_52_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5164_ clknet_leaf_33_clk_i net341 net284 VGND VGND VPWR VPWR i_mem_slice_stage.mem_state_o\[71\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_75_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2376_ i_mem_slice_stage.mem_state_o\[37\] VGND VGND VPWR VPWR _0330_ sky130_fd_sc_hd__inv_4
X_4115_ _1931_ VGND VGND VPWR VPWR _1932_ sky130_fd_sc_hd__inv_2
X_5095_ clknet_leaf_33_clk_i net353 net288 VGND VGND VPWR VPWR i_exec_stage.exec_state_o\[70\]
+ sky130_fd_sc_hd__dfrtp_1
X_4046_ _1091_ _0864_ VGND VGND VPWR VPWR _1864_ sky130_fd_sc_hd__nor2_1
XFILLER_0_78_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4948_ clknet_leaf_2_clk_i _0128_ net283 VGND VGND VPWR VPWR i_decode_stage.reg_meta_o\[9\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_46_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4879_ clknet_leaf_19_clk_i _0059_ net296 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[63\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_34_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_30_510 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xoutput270 net270 VGND VGND VPWR VPWR rf_wr_data_o[6] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_100_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_69_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_84_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_65_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_705 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_716 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_727 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_738 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_749 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_17_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_45_99 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_48_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_48_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2994_ _0324_ _0326_ i_decode_stage.reg_meta_o\[14\] VGND VGND VPWR VPWR _0906_ sky130_fd_sc_hd__o21a_1
X_4802_ _2323_ VGND VGND VPWR VPWR _0296_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_9_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4733_ net221 i_decode_stage.fetch_state_i\[61\] _1927_ VGND VGND VPWR VPWR _2289_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_16_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4664_ i_decode_stage.fetch_state_i\[22\] _1929_ _2114_ VGND VGND VPWR VPWR _0223_
+ sky130_fd_sc_hd__a21o_1
XFILLER_0_43_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3615_ _1500_ _1506_ VGND VGND VPWR VPWR _1507_ sky130_fd_sc_hd__or2_1
XFILLER_0_12_510 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4595_ _2225_ VGND VGND VPWR VPWR _0187_ sky130_fd_sc_hd__clkbuf_1
X_3546_ _0662_ _0587_ _1348_ _1440_ _0584_ VGND VGND VPWR VPWR _1441_ sky130_fd_sc_hd__o32a_1
X_3477_ _1287_ _1125_ _1137_ _1088_ _1374_ VGND VGND VPWR VPWR _1375_ sky130_fd_sc_hd__o221ai_1
XFILLER_0_86_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5216_ clknet_leaf_29_clk_i _0215_ net285 VGND VGND VPWR VPWR i_decode_stage.fetch_state_i\[14\]
+ sky130_fd_sc_hd__dfrtp_1
X_2428_ i_exec_stage.data_fwd_o\[1\] _0352_ _0355_ _0357_ VGND VGND VPWR VPWR _0380_
+ sky130_fd_sc_hd__or4_1
X_5147_ clknet_leaf_15_clk_i net352 net293 VGND VGND VPWR VPWR i_mem_slice_stage.mem_state_o\[54\]
+ sky130_fd_sc_hd__dfrtp_1
X_2359_ i_exec_stage.data_fwd_o\[37\] i_decode_stage.decode_state_o\[128\] VGND VGND
+ VPWR VPWR _0313_ sky130_fd_sc_hd__or2b_1
X_5078_ clknet_leaf_43_clk_i i_decode_stage.decode_state_o\[22\] net280 VGND VGND
+ VPWR VPWR i_exec_stage.exec_state_o\[53\] sky130_fd_sc_hd__dfrtp_1
X_4029_ _1843_ _1844_ _1845_ _1846_ VGND VGND VPWR VPWR _1847_ sky130_fd_sc_hd__or4b_1
XFILLER_0_66_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_421 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_15_36 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_57_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_31_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3400_ _1287_ _1300_ VGND VGND VPWR VPWR _1301_ sky130_fd_sc_hd__nor2_1
X_4380_ net207 _1840_ VGND VGND VPWR VPWR _2094_ sky130_fd_sc_hd__or2_1
X_3331_ _1212_ _1233_ _0898_ VGND VGND VPWR VPWR _1234_ sky130_fd_sc_hd__o21a_1
XTAP_502 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_513 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_524 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3262_ _1148_ _1145_ _0891_ VGND VGND VPWR VPWR _1167_ sky130_fd_sc_hd__a21o_1
XTAP_535 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_546 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_557 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3193_ _1104_ VGND VGND VPWR VPWR i_exec_stage.alu_out\[0\] sky130_fd_sc_hd__buf_4
X_5001_ clknet_leaf_1_clk_i _0181_ net283 VGND VGND VPWR VPWR i_decode_stage.reg_meta_o\[62\]
+ sky130_fd_sc_hd__dfrtp_1
XTAP_568 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_579 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2977_ _0428_ _0405_ _0888_ VGND VGND VPWR VPWR _0889_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_44_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4716_ _2280_ VGND VGND VPWR VPWR _0253_ sky130_fd_sc_hd__clkbuf_1
X_4647_ i_decode_stage.fetch_state_i\[13\] _2083_ _2234_ VGND VGND VPWR VPWR _2251_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_31_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4578_ i_decode_stage.reg_meta_o\[60\] net74 _2207_ VGND VGND VPWR VPWR _2217_ sky130_fd_sc_hd__mux2_1
X_3529_ _1129_ _1417_ _1420_ _0833_ _1424_ VGND VGND VPWR VPWR _1425_ sky130_fd_sc_hd__a221o_1
XFILLER_0_94_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_39_248 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_94_398 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_47_281 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_30_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2900_ _0500_ _0814_ VGND VGND VPWR VPWR _0815_ sky130_fd_sc_hd__nor2_1
X_3880_ _0411_ _1744_ _1757_ VGND VGND VPWR VPWR net153 sky130_fd_sc_hd__a21o_4
XFILLER_0_73_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2831_ _0745_ VGND VGND VPWR VPWR _0746_ sky130_fd_sc_hd__inv_2
XFILLER_0_26_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_45_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2762_ _0396_ _0397_ _0398_ i_decode_stage.reg_meta_o\[49\] VGND VGND VPWR VPWR _0681_
+ sky130_fd_sc_hd__o31a_1
XFILLER_0_5_337 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_41_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4501_ _2177_ VGND VGND VPWR VPWR _0141_ sky130_fd_sc_hd__clkbuf_1
X_2693_ net249 i_decode_stage.reg_meta_o\[60\] _0457_ VGND VGND VPWR VPWR _0619_ sky130_fd_sc_hd__mux2_1
X_4432_ _1691_ _1703_ _1705_ _1924_ VGND VGND VPWR VPWR _2135_ sky130_fd_sc_hd__or4_1
X_4363_ net134 _2047_ _2048_ _2079_ _2080_ VGND VGND VPWR VPWR _0100_ sky130_fd_sc_hd__o221a_1
X_3314_ _1054_ _1071_ _0525_ VGND VGND VPWR VPWR _1218_ sky130_fd_sc_hd__mux2_1
XTAP_332 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_321 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_310 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4294_ _2028_ _2030_ _0346_ _1840_ VGND VGND VPWR VPWR _0081_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_67_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3245_ _0419_ _1148_ _0891_ _0424_ _1150_ VGND VGND VPWR VPWR _1151_ sky130_fd_sc_hd__o221a_1
XTAP_376 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_365 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_354 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_343 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_387 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_398 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3176_ _1074_ _0589_ VGND VGND VPWR VPWR _1088_ sky130_fd_sc_hd__nand2_4
XFILLER_0_95_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_49_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_76_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_91_379 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_8_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_67_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_67_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_55_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3030_ _0608_ _0857_ VGND VGND VPWR VPWR _0942_ sky130_fd_sc_hd__and2b_1
X_4981_ clknet_leaf_34_clk_i _0161_ net284 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[128\]
+ sky130_fd_sc_hd__dfrtp_4
X_3932_ _0803_ VGND VGND VPWR VPWR _1793_ sky130_fd_sc_hd__inv_2
XFILLER_0_58_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3863_ _1728_ _1729_ _1741_ VGND VGND VPWR VPWR net151 sky130_fd_sc_hd__a21o_4
X_2814_ i_decode_stage.reg_meta_o\[35\] _0727_ _0386_ _0728_ VGND VGND VPWR VPWR _0729_
+ sky130_fd_sc_hd__a211o_1
XFILLER_0_26_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3794_ _1674_ _1656_ _0764_ VGND VGND VPWR VPWR _1676_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_14_457 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_41_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2745_ i_mem_slice_stage.mem_state_o\[47\] i_mem_slice_stage.mem_state_o\[8\] _0453_
+ VGND VGND VPWR VPWR _0667_ sky130_fd_sc_hd__mux2_1
X_2676_ i_mem_slice_stage.mem_state_o\[85\] _0328_ _0604_ _0330_ VGND VGND VPWR VPWR
+ net247 sky130_fd_sc_hd__a22o_1
XFILLER_0_41_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4415_ net146 _1924_ VGND VGND VPWR VPWR _2121_ sky130_fd_sc_hd__or2_1
X_4346_ net230 _1840_ VGND VGND VPWR VPWR _2068_ sky130_fd_sc_hd__or2_1
XFILLER_0_1_373 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4277_ i_decode_stage.decode_state_o\[100\] net58 _2012_ VGND VGND VPWR VPWR _2018_
+ sky130_fd_sc_hd__mux2_1
X_3228_ _0540_ _1076_ _1133_ VGND VGND VPWR VPWR _1134_ sky130_fd_sc_hd__o21ai_1
X_3159_ _1068_ _1070_ _0421_ VGND VGND VPWR VPWR _1071_ sky130_fd_sc_hd__mux2_1
XFILLER_0_96_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_49_343 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_76_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_473 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_17_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_20_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_2_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_99_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_99_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_59_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_87_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_67_151 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_55_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_368 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_82_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_70_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_leaf_31_clk_i clknet_2_1__leaf_clk_i VGND VGND VPWR VPWR clknet_leaf_31_clk_i
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_11_405 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2530_ i_exec_stage.data_fwd_o\[22\] _0474_ _0460_ VGND VGND VPWR VPWR _0475_ sky130_fd_sc_hd__mux2_2
X_2461_ _0410_ VGND VGND VPWR VPWR _0411_ sky130_fd_sc_hd__buf_12
XFILLER_0_11_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4200_ _1978_ VGND VGND VPWR VPWR _0039_ sky130_fd_sc_hd__clkbuf_1
X_2392_ _0344_ VGND VGND VPWR VPWR _0345_ sky130_fd_sc_hd__buf_8
X_5180_ clknet_leaf_44_clk_i net350 net280 VGND VGND VPWR VPWR i_mem_slice_stage.mem_state_o\[87\]
+ sky130_fd_sc_hd__dfrtp_1
X_4131_ i_decode_stage.decode_state_o\[7\] _1929_ _1943_ VGND VGND VPWR VPWR _0005_
+ sky130_fd_sc_hd__a21o_1
XFILLER_0_47_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_3_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4062_ _1871_ _1873_ VGND VGND VPWR VPWR _1880_ sky130_fd_sc_hd__and2b_1
XFILLER_0_3_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_3_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3013_ _0386_ _0922_ _0923_ _0924_ VGND VGND VPWR VPWR _0925_ sky130_fd_sc_hd__o31ai_4
XFILLER_0_80_42 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_19_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4964_ clknet_leaf_3_clk_i _0144_ net284 VGND VGND VPWR VPWR i_decode_stage.reg_meta_o\[25\]
+ sky130_fd_sc_hd__dfrtp_1
X_3915_ _1782_ _1774_ _1783_ VGND VGND VPWR VPWR net171 sky130_fd_sc_hd__a21o_1
X_4895_ clknet_leaf_19_clk_i _0075_ net296 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[133\]
+ sky130_fd_sc_hd__dfrtp_4
X_3846_ _1715_ _1722_ _1725_ VGND VGND VPWR VPWR _1726_ sky130_fd_sc_hd__or3b_1
XFILLER_0_6_421 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_80_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3777_ _0411_ _1658_ _1659_ VGND VGND VPWR VPWR _1660_ sky130_fd_sc_hd__and3_1
X_2728_ i_mem_slice_stage.mem_state_o\[81\] _0328_ _0651_ _0330_ VGND VGND VPWR VPWR
+ net243 sky130_fd_sc_hd__a22o_1
XFILLER_0_14_287 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2659_ _0384_ net192 _0580_ VGND VGND VPWR VPWR _0589_ sky130_fd_sc_hd__o21ai_4
X_4329_ net156 _2047_ _2048_ _2053_ _2054_ VGND VGND VPWR VPWR _0092_ sky130_fd_sc_hd__o221a_1
XTAP_1114 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1103 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1136 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1125 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_909 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3700_ _1552_ _1586_ _0422_ VGND VGND VPWR VPWR _1587_ sky130_fd_sc_hd__mux2_1
XFILLER_0_83_485 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4680_ i_decode_stage.fetch_state_i\[34\] _1929_ _2043_ VGND VGND VPWR VPWR _0235_
+ sky130_fd_sc_hd__a21bo_1
XFILLER_0_43_305 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_50_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3631_ _0448_ _0717_ _1521_ _0712_ VGND VGND VPWR VPWR _1522_ sky130_fd_sc_hd__a211o_1
X_3562_ _0344_ _0608_ _1077_ VGND VGND VPWR VPWR _1456_ sky130_fd_sc_hd__a21oi_1
X_2513_ _0459_ VGND VGND VPWR VPWR _0460_ sky130_fd_sc_hd__buf_8
X_5301_ clknet_leaf_36_clk_i _0300_ VGND VGND VPWR VPWR i_exec_stage.data_fwd_o\[35\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_59_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3493_ _0540_ _1388_ _1389_ VGND VGND VPWR VPWR _1390_ sky130_fd_sc_hd__o21ai_1
X_5232_ clknet_leaf_25_clk_i _0231_ net290 VGND VGND VPWR VPWR i_decode_stage.fetch_state_i\[30\]
+ sky130_fd_sc_hd__dfrtp_1
X_2444_ _0384_ net178 _0393_ VGND VGND VPWR VPWR _0394_ sky130_fd_sc_hd__o21ai_4
X_5163_ clknet_leaf_14_clk_i net340 net295 VGND VGND VPWR VPWR i_mem_slice_stage.mem_state_o\[70\]
+ sky130_fd_sc_hd__dfrtp_1
X_2375_ i_mem_slice_stage.mem_state_o\[39\] i_mem_slice_stage.mem_state_o\[0\] i_mem_slice_stage.mem_state_o\[36\]
+ VGND VGND VPWR VPWR _0329_ sky130_fd_sc_hd__mux2_1
X_4114_ net61 _1930_ VGND VGND VPWR VPWR _1931_ sky130_fd_sc_hd__nand2_1
X_5094_ clknet_leaf_23_clk_i i_decode_stage.decode_state_o\[38\] net289 VGND VGND
+ VPWR VPWR i_exec_stage.exec_state_o\[69\] sky130_fd_sc_hd__dfrtp_1
X_4045_ _1862_ net195 VGND VGND VPWR VPWR _1863_ sky130_fd_sc_hd__and2_1
X_4947_ clknet_leaf_5_clk_i _0127_ net283 VGND VGND VPWR VPWR i_decode_stage.reg_meta_o\[8\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_34_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4878_ clknet_2_3__leaf_clk_i _0058_ net289 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[62\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_6_240 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_61_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_61_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3829_ _0763_ _1671_ _1693_ _0762_ VGND VGND VPWR VPWR _1709_ sky130_fd_sc_hd__a211o_1
XFILLER_0_61_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_100_421 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xoutput260 net260 VGND VGND VPWR VPWR rf_wr_data_o[26] sky130_fd_sc_hd__buf_2
Xoutput271 net271 VGND VGND VPWR VPWR rf_wr_data_o[7] sky130_fd_sc_hd__buf_2
XFILLER_0_69_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_84_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_80_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_20_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_405 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_0_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_706 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_717 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_728 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_739 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2993_ _2336_ _2341_ net272 VGND VGND VPWR VPWR _0905_ sky130_fd_sc_hd__and3_1
XFILLER_0_56_441 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4801_ i_exec_stage.data_fwd_o\[31\] net153 _1838_ VGND VGND VPWR VPWR _2323_ sky130_fd_sc_hd__mux2_1
X_4732_ _2288_ VGND VGND VPWR VPWR _0261_ sky130_fd_sc_hd__clkbuf_1
X_4663_ i_decode_stage.fetch_state_i\[21\] _1929_ _2110_ VGND VGND VPWR VPWR _0222_
+ sky130_fd_sc_hd__a21o_1
XFILLER_0_56_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3614_ _1074_ _1073_ _1501_ _1504_ _1505_ VGND VGND VPWR VPWR _1506_ sky130_fd_sc_hd__a311o_1
X_4594_ i_decode_stage.reg_meta_o\[68\] net83 _2207_ VGND VGND VPWR VPWR _2225_ sky130_fd_sc_hd__mux2_1
X_3545_ _0582_ _1256_ _1322_ VGND VGND VPWR VPWR _1440_ sky130_fd_sc_hd__o21a_1
X_3476_ _1154_ _1326_ _1373_ _1041_ VGND VGND VPWR VPWR _1374_ sky130_fd_sc_hd__o22a_1
X_2427_ _0376_ _0377_ _0378_ i_decode_stage.reg_meta_o\[44\] VGND VGND VPWR VPWR _0379_
+ sky130_fd_sc_hd__o31a_1
X_5215_ clknet_leaf_31_clk_i _0214_ net285 VGND VGND VPWR VPWR i_decode_stage.fetch_state_i\[13\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_86_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2358_ i_decode_stage.decode_state_o\[128\] i_exec_stage.data_fwd_o\[37\] VGND VGND
+ VPWR VPWR _0312_ sky130_fd_sc_hd__or2b_1
X_5146_ clknet_leaf_10_clk_i net402 net292 VGND VGND VPWR VPWR i_mem_slice_stage.mem_state_o\[53\]
+ sky130_fd_sc_hd__dfrtp_1
X_5077_ clknet_leaf_41_clk_i i_decode_stage.decode_state_o\[21\] net280 VGND VGND
+ VPWR VPWR i_exec_stage.exec_state_o\[52\] sky130_fd_sc_hd__dfrtp_1
X_4028_ _0498_ _0812_ _0978_ _0490_ VGND VGND VPWR VPWR _1846_ sky130_fd_sc_hd__o22a_1
XFILLER_0_19_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_62_433 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_34_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_62_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_100_240 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_30_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_85_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_33_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3330_ _0447_ _0883_ VGND VGND VPWR VPWR _1233_ sky130_fd_sc_hd__nor2_1
XTAP_503 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_514 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_525 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3261_ _0660_ _0703_ _1164_ _1165_ VGND VGND VPWR VPWR _1166_ sky130_fd_sc_hd__a211o_1
X_5000_ clknet_leaf_44_clk_i _0180_ net281 VGND VGND VPWR VPWR i_decode_stage.reg_meta_o\[61\]
+ sky130_fd_sc_hd__dfrtp_1
XTAP_536 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_547 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_558 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3192_ _0409_ _1036_ _1039_ _1103_ VGND VGND VPWR VPWR _1104_ sky130_fd_sc_hd__a31o_1
XTAP_569 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_15_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_8_346 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2976_ _0527_ _0404_ VGND VGND VPWR VPWR _0888_ sky130_fd_sc_hd__nor2_1
X_4715_ net212 i_decode_stage.fetch_state_i\[52\] _1927_ VGND VGND VPWR VPWR _2280_
+ sky130_fd_sc_hd__mux2_1
X_4646_ _2250_ VGND VGND VPWR VPWR _0213_ sky130_fd_sc_hd__clkbuf_1
X_4577_ _2216_ VGND VGND VPWR VPWR _0178_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_24_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_12_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3528_ _1129_ _1423_ VGND VGND VPWR VPWR _1424_ sky130_fd_sc_hd__nor2_1
X_3459_ _1240_ _1357_ _0523_ VGND VGND VPWR VPWR _1358_ sky130_fd_sc_hd__mux2_1
X_5129_ clknet_leaf_4_clk_i i_exec_stage.exec_state_o\[4\] net284 VGND VGND VPWR VPWR
+ i_mem_slice_stage.mem_state_o\[36\] sky130_fd_sc_hd__dfrtp_4
XFILLER_0_98_127 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_94_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_94_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_22_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold70 i_exec_stage.reg_meta_o\[1\] VGND VGND VPWR VPWR net407 sky130_fd_sc_hd__clkdlybuf4s25_1
X_2830_ _0725_ _0735_ _0738_ _0744_ VGND VGND VPWR VPWR _0745_ sky130_fd_sc_hd__a22o_1
XFILLER_0_85_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2761_ _0363_ _0369_ _0374_ net269 VGND VGND VPWR VPWR _0680_ sky130_fd_sc_hd__and4_1
XFILLER_0_5_349 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_26_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2692_ i_mem_slice_stage.mem_state_o\[87\] _0452_ _0618_ _0455_ VGND VGND VPWR VPWR
+ net249 sky130_fd_sc_hd__a22o_1
X_4500_ i_decode_stage.reg_meta_o\[22\] net106 _2012_ VGND VGND VPWR VPWR _2177_ sky130_fd_sc_hd__mux2_1
XFILLER_0_53_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4431_ net218 _1928_ _2130_ _2134_ VGND VGND VPWR VPWR _0114_ sky130_fd_sc_hd__a22o_1
XANTENNA_1 _0467_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4362_ net203 _1840_ VGND VGND VPWR VPWR _2080_ sky130_fd_sc_hd__or2_1
XFILLER_0_6_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3313_ _0662_ _1065_ _0707_ VGND VGND VPWR VPWR _1217_ sky130_fd_sc_hd__o21ai_1
XTAP_333 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_322 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_311 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_300 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4293_ _1928_ _2021_ VGND VGND VPWR VPWR _2030_ sky130_fd_sc_hd__nor2_1
X_3244_ _1149_ _0703_ VGND VGND VPWR VPWR _1150_ sky130_fd_sc_hd__nand2_1
XTAP_366 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_355 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_344 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_377 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_388 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_399 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3175_ _0593_ _0589_ VGND VGND VPWR VPWR _1087_ sky130_fd_sc_hd__nor2_2
XFILLER_0_83_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_88_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_32_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2959_ _0322_ _0870_ _0871_ _0872_ VGND VGND VPWR VPWR _0873_ sky130_fd_sc_hd__a31o_1
XFILLER_0_44_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_4_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_32_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4629_ i_decode_stage.fetch_state_i\[4\] _2053_ _2234_ VGND VGND VPWR VPWR _2242_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_99_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_94_141 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_67_366 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_70_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_35_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_50_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4980_ clknet_leaf_6_clk_i _0160_ net284 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[127\]
+ sky130_fd_sc_hd__dfrtp_4
XFILLER_0_85_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3931_ _1792_ VGND VGND VPWR VPWR net179 sky130_fd_sc_hd__inv_2
X_3862_ _1017_ _1730_ _1731_ _1740_ VGND VGND VPWR VPWR _1741_ sky130_fd_sc_hd__a31o_1
X_2813_ _2336_ _2341_ net263 VGND VGND VPWR VPWR _0728_ sky130_fd_sc_hd__and3_1
XFILLER_0_5_113 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3793_ _0764_ _1674_ _1656_ VGND VGND VPWR VPWR _1675_ sky130_fd_sc_hd__and3_1
X_2744_ _0346_ i_decode_stage.decode_state_o\[131\] _0347_ _0665_ VGND VGND VPWR VPWR
+ _0666_ sky130_fd_sc_hd__a22oi_4
XFILLER_0_14_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2675_ i_mem_slice_stage.mem_state_o\[53\] i_mem_slice_stage.mem_state_o\[14\] _0453_
+ VGND VGND VPWR VPWR _0604_ sky130_fd_sc_hd__mux2_1
X_4414_ _2120_ VGND VGND VPWR VPWR _0111_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_41_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4345_ _2065_ _2066_ VGND VGND VPWR VPWR _2067_ sky130_fd_sc_hd__and2b_1
XFILLER_0_1_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4276_ _2017_ VGND VGND VPWR VPWR _0076_ sky130_fd_sc_hd__clkbuf_1
X_3227_ _0422_ _1058_ VGND VGND VPWR VPWR _1133_ sky130_fd_sc_hd__or2_1
XFILLER_0_94_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3158_ _0344_ _0470_ _1069_ VGND VGND VPWR VPWR _1070_ sky130_fd_sc_hd__a21oi_1
X_3089_ _0992_ _0997_ _1000_ VGND VGND VPWR VPWR _1001_ sky130_fd_sc_hd__a21o_1
XFILLER_0_76_141 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_49_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_91_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_91_133 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_9_485 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_17_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_95_461 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_67_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_70_317 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_63_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2460_ _0408_ _0409_ VGND VGND VPWR VPWR _0410_ sky130_fd_sc_hd__and2b_1
XFILLER_0_11_417 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2391_ _0343_ VGND VGND VPWR VPWR _0344_ sky130_fd_sc_hd__buf_8
X_4130_ net60 _1931_ _1942_ net64 _1840_ VGND VGND VPWR VPWR _1943_ sky130_fd_sc_hd__o221a_1
X_4061_ _1871_ _1876_ _1878_ VGND VGND VPWR VPWR _1879_ sky130_fd_sc_hd__or3b_1
X_3012_ i_exec_stage.data_fwd_o\[12\] _0311_ _0316_ _0320_ VGND VGND VPWR VPWR _0924_
+ sky130_fd_sc_hd__or4_2
XFILLER_0_86_450 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4963_ clknet_leaf_3_clk_i _0143_ net284 VGND VGND VPWR VPWR i_decode_stage.reg_meta_o\[24\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_58_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_73_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3914_ _0864_ _1774_ VGND VGND VPWR VPWR _1783_ sky130_fd_sc_hd__nor2_1
X_4894_ clknet_leaf_18_clk_i _0074_ net296 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[132\]
+ sky130_fd_sc_hd__dfrtp_4
X_3845_ _0430_ _1723_ _1724_ VGND VGND VPWR VPWR _1725_ sky130_fd_sc_hd__or3_1
XFILLER_0_13_81 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_6_433 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_73_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_6_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3776_ _1657_ _0779_ _1638_ VGND VGND VPWR VPWR _1659_ sky130_fd_sc_hd__or3_1
XFILLER_0_73_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2727_ i_mem_slice_stage.mem_state_o\[49\] i_mem_slice_stage.mem_state_o\[10\] _0453_
+ VGND VGND VPWR VPWR _0651_ sky130_fd_sc_hd__mux2_1
XFILLER_0_14_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2658_ _0525_ _0587_ _0572_ VGND VGND VPWR VPWR _0588_ sky130_fd_sc_hd__a21o_1
XFILLER_0_1_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2589_ i_mem_slice_stage.mem_state_o\[68\] i_mem_slice_stage.mem_state_o\[29\] _0453_
+ VGND VGND VPWR VPWR _0528_ sky130_fd_sc_hd__mux2_2
X_4328_ net226 _1840_ VGND VGND VPWR VPWR _2054_ sky130_fd_sc_hd__or2_1
X_4259_ _2008_ VGND VGND VPWR VPWR _0068_ sky130_fd_sc_hd__clkbuf_1
XTAP_1104 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1137 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1126 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1115 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_84_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_49_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_92_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_16_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_317 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3630_ _0707_ _1519_ _1520_ _0709_ VGND VGND VPWR VPWR _1521_ sky130_fd_sc_hd__o211a_1
XFILLER_0_83_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3561_ _0858_ VGND VGND VPWR VPWR _1455_ sky130_fd_sc_hd__inv_2
XFILLER_0_3_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2512_ _0352_ _0355_ _0357_ VGND VGND VPWR VPWR _0459_ sky130_fd_sc_hd__or3_1
X_5300_ clknet_leaf_35_clk_i _0299_ VGND VGND VPWR VPWR i_exec_stage.data_fwd_o\[34\]
+ sky130_fd_sc_hd__dfxtp_1
X_3492_ _0421_ _1356_ VGND VGND VPWR VPWR _1389_ sky130_fd_sc_hd__or2_1
XFILLER_0_59_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5231_ clknet_leaf_26_clk_i _0230_ net289 VGND VGND VPWR VPWR i_decode_stage.fetch_state_i\[29\]
+ sky130_fd_sc_hd__dfrtp_1
X_2443_ i_decode_stage.decode_state_o\[41\] _0339_ _0392_ _2333_ VGND VGND VPWR VPWR
+ _0393_ sky130_fd_sc_hd__a211o_1
X_5162_ clknet_leaf_16_clk_i net414 net295 VGND VGND VPWR VPWR i_mem_slice_stage.mem_state_o\[69\]
+ sky130_fd_sc_hd__dfrtp_1
X_2374_ _0327_ VGND VGND VPWR VPWR _0328_ sky130_fd_sc_hd__clkbuf_8
XFILLER_0_75_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5093_ clknet_leaf_27_clk_i i_decode_stage.decode_state_o\[37\] net289 VGND VGND
+ VPWR VPWR i_exec_stage.exec_state_o\[68\] sky130_fd_sc_hd__dfrtp_1
X_4113_ net59 net56 net34 net45 VGND VGND VPWR VPWR _1930_ sky130_fd_sc_hd__and4bb_2
X_4044_ _0676_ VGND VGND VPWR VPWR _1862_ sky130_fd_sc_hd__inv_2
XFILLER_0_91_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_78_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_93_206 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4946_ clknet_leaf_1_clk_i _0126_ net283 VGND VGND VPWR VPWR i_decode_stage.reg_meta_o\[7\]
+ sky130_fd_sc_hd__dfrtp_1
X_4877_ clknet_leaf_22_clk_i _0057_ net288 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[61\]
+ sky130_fd_sc_hd__dfrtp_1
X_3828_ _1009_ _1707_ _0773_ _0782_ VGND VGND VPWR VPWR _1708_ sky130_fd_sc_hd__or4_1
X_3759_ _0540_ _1642_ VGND VGND VPWR VPWR _1643_ sky130_fd_sc_hd__nor2_1
XFILLER_0_100_433 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xoutput261 net261 VGND VGND VPWR VPWR rf_wr_data_o[27] sky130_fd_sc_hd__buf_2
Xoutput250 net250 VGND VGND VPWR VPWR rf_wr_data_o[17] sky130_fd_sc_hd__buf_2
XFILLER_0_100_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_10_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput272 net272 VGND VGND VPWR VPWR rf_wr_data_o[8] sky130_fd_sc_hd__buf_2
Xclkbuf_leaf_30_clk_i clknet_2_1__leaf_clk_i VGND VGND VPWR VPWR clknet_leaf_30_clk_i
+ sky130_fd_sc_hd__clkbuf_16
XFILLER_0_69_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_37_122 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_80_434 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_25_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_489 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_0_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_707 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_718 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_729 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_57 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4800_ _2322_ VGND VGND VPWR VPWR _0295_ sky130_fd_sc_hd__clkbuf_1
X_2992_ _0876_ _0902_ _0903_ VGND VGND VPWR VPWR _0904_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_90_209 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4731_ net220 i_decode_stage.fetch_state_i\[60\] _1927_ VGND VGND VPWR VPWR _2288_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_56_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4662_ _2258_ VGND VGND VPWR VPWR _0221_ sky130_fd_sc_hd__clkbuf_1
X_3613_ _1045_ _1313_ _0448_ VGND VGND VPWR VPWR _1505_ sky130_fd_sc_hd__o21a_1
XFILLER_0_71_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_12_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_3_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_24_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4593_ _2224_ VGND VGND VPWR VPWR _0186_ sky130_fd_sc_hd__clkbuf_1
X_3544_ _0424_ _1438_ VGND VGND VPWR VPWR _1439_ sky130_fd_sc_hd__nand2_1
X_3475_ _0660_ _1284_ _1372_ VGND VGND VPWR VPWR _1373_ sky130_fd_sc_hd__o21ai_1
X_2426_ i_decode_stage.reg_meta_o\[81\] net274 _0359_ VGND VGND VPWR VPWR _0378_ sky130_fd_sc_hd__nand3_4
X_5214_ clknet_leaf_30_clk_i _0213_ net285 VGND VGND VPWR VPWR i_decode_stage.fetch_state_i\[12\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_19_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2357_ _0307_ _0308_ _0309_ _0310_ VGND VGND VPWR VPWR _0311_ sky130_fd_sc_hd__nand4_2
XFILLER_0_36_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5145_ clknet_leaf_8_clk_i net375 net297 VGND VGND VPWR VPWR i_mem_slice_stage.mem_state_o\[52\]
+ sky130_fd_sc_hd__dfrtp_1
X_5076_ clknet_leaf_42_clk_i net356 net280 VGND VGND VPWR VPWR i_exec_stage.exec_state_o\[51\]
+ sky130_fd_sc_hd__dfrtp_1
X_4027_ _0490_ _0978_ _0986_ _0505_ VGND VGND VPWR VPWR _1845_ sky130_fd_sc_hd__a22o_1
X_4929_ clknet_leaf_32_clk_i _0109_ net287 VGND VGND VPWR VPWR net213 sky130_fd_sc_hd__dfrtp_2
XFILLER_0_62_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_62_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_26 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_38_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_65_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_80_253 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_25_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_0_225 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_504 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_515 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3260_ _0889_ _0892_ VGND VGND VPWR VPWR _1165_ sky130_fd_sc_hd__nor2_1
XTAP_526 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_537 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_548 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3191_ _0709_ _1045_ _1049_ _1102_ VGND VGND VPWR VPWR _1103_ sky130_fd_sc_hd__a211o_1
XTAP_559 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2975_ _0589_ _0691_ VGND VGND VPWR VPWR _0887_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_8_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4714_ _2279_ VGND VGND VPWR VPWR _0252_ sky130_fd_sc_hd__clkbuf_1
X_4645_ i_decode_stage.fetch_state_i\[12\] _2079_ _2234_ VGND VGND VPWR VPWR _2250_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_71_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4576_ i_decode_stage.reg_meta_o\[59\] net73 _2207_ VGND VGND VPWR VPWR _2216_ sky130_fd_sc_hd__mux2_1
XFILLER_0_31_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_97_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3527_ _0593_ _1422_ VGND VGND VPWR VPWR _1423_ sky130_fd_sc_hd__or2_1
X_3458_ _1295_ _1356_ _0421_ VGND VGND VPWR VPWR _1357_ sky130_fd_sc_hd__mux2_1
X_3389_ _1129_ _1276_ _1278_ _1290_ VGND VGND VPWR VPWR _1291_ sky130_fd_sc_hd__o31a_1
X_2409_ _0359_ _0360_ _0361_ VGND VGND VPWR VPWR _0362_ sky130_fd_sc_hd__and3_1
X_5128_ clknet_leaf_14_clk_i i_mem_slice_stage.pre_data\[31\] net295 VGND VGND VPWR
+ VPWR i_mem_slice_stage.mem_state_o\[31\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_98_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_5059_ clknet_leaf_12_clk_i net149 net293 VGND VGND VPWR VPWR i_exec_stage.exec_state_o\[34\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_62_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_7_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_253 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_50_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold71 i_exec_stage.exec_state_o\[19\] VGND VGND VPWR VPWR net408 sky130_fd_sc_hd__clkdlybuf4s25_1
Xhold60 i_exec_stage.exec_state_o\[15\] VGND VGND VPWR VPWR net397 sky130_fd_sc_hd__clkdlybuf4s25_1
X_2760_ i_mem_slice_stage.mem_state_o\[76\] _0328_ _0679_ _0330_ VGND VGND VPWR VPWR
+ net269 sky130_fd_sc_hd__a22o_1
XFILLER_0_26_489 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2691_ i_mem_slice_stage.mem_state_o\[55\] i_mem_slice_stage.mem_state_o\[16\] _0453_
+ VGND VGND VPWR VPWR _0618_ sky130_fd_sc_hd__mux2_1
XANTENNA_2 _0484_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4430_ _2042_ _2133_ VGND VGND VPWR VPWR _2134_ sky130_fd_sc_hd__or2_1
X_4361_ net203 _2075_ VGND VGND VPWR VPWR _2079_ sky130_fd_sc_hd__xor2_1
XFILLER_0_67_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3312_ _0418_ _0416_ VGND VGND VPWR VPWR _1216_ sky130_fd_sc_hd__and2_2
XTAP_323 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_312 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_301 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_6_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4292_ _0631_ _1928_ _2029_ VGND VGND VPWR VPWR _0080_ sky130_fd_sc_hd__a21oi_1
X_3243_ i_decode_stage.decode_state_o\[237\] _0416_ VGND VGND VPWR VPWR _1149_ sky130_fd_sc_hd__and2_2
XTAP_367 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_356 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_345 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_334 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_378 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_389 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3174_ _1079_ _1085_ _0523_ VGND VGND VPWR VPWR _1086_ sky130_fd_sc_hd__mux2_1
XFILLER_0_16_70 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XPHY_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_76_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_91_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_423 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2958_ i_exec_stage.data_fwd_o\[8\] _0322_ VGND VGND VPWR VPWR _0872_ sky130_fd_sc_hd__nor2_1
XFILLER_0_44_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4628_ _2241_ VGND VGND VPWR VPWR _0204_ sky130_fd_sc_hd__clkbuf_1
X_2889_ i_decode_stage.decode_state_o\[61\] _0731_ _0733_ VGND VGND VPWR VPWR _0804_
+ sky130_fd_sc_hd__a21oi_1
X_4559_ _0722_ VGND VGND VPWR VPWR _2207_ sky130_fd_sc_hd__buf_12
XFILLER_0_12_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_890 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_153 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_67_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_94_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_348 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_35_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_309 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_35_286 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_50_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_77_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_53_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3930_ _0444_ _0812_ _0601_ VGND VGND VPWR VPWR _1792_ sky130_fd_sc_hd__mux2_1
X_3861_ _1198_ _0736_ _1739_ VGND VGND VPWR VPWR _1740_ sky130_fd_sc_hd__a21o_1
XFILLER_0_18_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_58_378 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2812_ _2336_ _2341_ VGND VGND VPWR VPWR _0727_ sky130_fd_sc_hd__nand2_8
X_3792_ _1007_ VGND VGND VPWR VPWR _1674_ sky130_fd_sc_hd__inv_2
XFILLER_0_73_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_14_404 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_5_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2743_ i_exec_stage.data_fwd_o\[8\] _0664_ _0460_ VGND VGND VPWR VPWR _0665_ sky130_fd_sc_hd__mux2_2
XFILLER_0_81_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2674_ _0450_ _0600_ _0602_ _0492_ VGND VGND VPWR VPWR _0603_ sky130_fd_sc_hd__a2bb2o_4
X_4413_ net215 _2119_ _2012_ VGND VGND VPWR VPWR _2120_ sky130_fd_sc_hd__mux2_1
X_4344_ net228 net229 _2055_ net230 VGND VGND VPWR VPWR _2066_ sky130_fd_sc_hd__a31o_1
X_4275_ net57 i_decode_stage.decode_state_o\[134\] _1967_ VGND VGND VPWR VPWR _2017_
+ sky130_fd_sc_hd__mux2_1
X_3226_ _1129_ _1131_ _0594_ VGND VGND VPWR VPWR _1132_ sky130_fd_sc_hd__o21ai_1
X_3157_ _0465_ _0563_ VGND VGND VPWR VPWR _1069_ sky130_fd_sc_hd__and2_1
X_3088_ _0983_ _0998_ _0999_ VGND VGND VPWR VPWR _1000_ sky130_fd_sc_hd__a21o_1
XFILLER_0_76_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_145 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_64_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_72_392 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_99_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_95_473 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_55_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_70_329 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_23_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_11_429 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2390_ _0342_ VGND VGND VPWR VPWR _0343_ sky130_fd_sc_hd__buf_6
X_4060_ _0615_ _1785_ _0908_ _0671_ _1877_ VGND VGND VPWR VPWR _1878_ sky130_fd_sc_hd__o221a_1
X_3011_ _0324_ _0326_ i_decode_stage.reg_meta_o\[17\] VGND VGND VPWR VPWR _0923_ sky130_fd_sc_hd__o21a_1
XFILLER_0_64_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4962_ clknet_leaf_3_clk_i _0142_ net283 VGND VGND VPWR VPWR i_decode_stage.reg_meta_o\[23\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_86_462 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3913_ _0726_ _0835_ _0836_ _0837_ VGND VGND VPWR VPWR _1782_ sky130_fd_sc_hd__a31oi_4
X_4893_ clknet_leaf_19_clk_i _0073_ net296 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[131\]
+ sky130_fd_sc_hd__dfrtp_4
X_3844_ _1016_ _1004_ _1012_ VGND VGND VPWR VPWR _1724_ sky130_fd_sc_hd__and3_1
XFILLER_0_6_401 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_58_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_445 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3775_ _0779_ _1638_ _1657_ VGND VGND VPWR VPWR _1658_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_6_489 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2726_ _0346_ i_decode_stage.decode_state_o\[133\] _0347_ _0649_ VGND VGND VPWR VPWR
+ _0650_ sky130_fd_sc_hd__a22oi_4
X_2657_ _0421_ _0586_ _0539_ VGND VGND VPWR VPWR _0587_ sky130_fd_sc_hd__o21a_1
X_2588_ _0526_ VGND VGND VPWR VPWR _0527_ sky130_fd_sc_hd__buf_2
XFILLER_0_1_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4327_ _2051_ _2052_ VGND VGND VPWR VPWR _2053_ sky130_fd_sc_hd__nor2_1
X_4258_ net37 i_decode_stage.decode_state_o\[0\] _1967_ VGND VGND VPWR VPWR _2008_
+ sky130_fd_sc_hd__mux2_1
X_3209_ _0540_ _1062_ VGND VGND VPWR VPWR _1115_ sky130_fd_sc_hd__or2_1
XFILLER_0_96_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4189_ i_decode_stage.fetch_state_i\[30\] i_decode_stage.decode_state_o\[38\] _1967_
+ VGND VGND VPWR VPWR _1973_ sky130_fd_sc_hd__mux2_1
XFILLER_0_69_418 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_1105 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1138 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1127 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1116 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_92_421 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_37_337 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_64_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_83_421 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_43_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_70_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3560_ _1450_ _1453_ VGND VGND VPWR VPWR _1454_ sky130_fd_sc_hd__nor2_1
X_2511_ net257 i_decode_stage.reg_meta_o\[67\] _0457_ VGND VGND VPWR VPWR _0458_ sky130_fd_sc_hd__mux2_1
X_3491_ _0344_ _0633_ _0657_ VGND VGND VPWR VPWR _1388_ sky130_fd_sc_hd__a21o_1
X_5230_ clknet_leaf_28_clk_i _0229_ net290 VGND VGND VPWR VPWR i_decode_stage.fetch_state_i\[28\]
+ sky130_fd_sc_hd__dfrtp_1
X_2442_ i_decode_stage.decode_state_o\[125\] _0337_ _0338_ i_decode_stage.decode_state_o\[137\]
+ VGND VGND VPWR VPWR _0392_ sky130_fd_sc_hd__a22o_1
X_5161_ clknet_leaf_16_clk_i net413 net295 VGND VGND VPWR VPWR i_mem_slice_stage.mem_state_o\[68\]
+ sky130_fd_sc_hd__dfrtp_1
X_2373_ i_mem_slice_stage.mem_state_o\[36\] i_mem_slice_stage.mem_state_o\[37\] VGND
+ VGND VPWR VPWR _0327_ sky130_fd_sc_hd__and2_1
X_5092_ clknet_leaf_28_clk_i net411 net290 VGND VGND VPWR VPWR i_exec_stage.exec_state_o\[67\]
+ sky130_fd_sc_hd__dfrtp_1
X_4112_ _1928_ VGND VGND VPWR VPWR _1929_ sky130_fd_sc_hd__clkbuf_8
X_4043_ _1857_ _1858_ _1859_ _1860_ VGND VGND VPWR VPWR _1861_ sky130_fd_sc_hd__a211oi_1
XFILLER_0_93_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4945_ clknet_leaf_2_clk_i _0125_ net283 VGND VGND VPWR VPWR i_decode_stage.reg_meta_o\[6\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_74_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_337 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_74_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_46_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4876_ clknet_leaf_22_clk_i _0056_ net288 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[60\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_6_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3827_ _0764_ VGND VGND VPWR VPWR _1707_ sky130_fd_sc_hd__inv_1
X_3758_ _0344_ _0470_ _1050_ VGND VGND VPWR VPWR _1642_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_6_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_61_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2709_ i_mem_slice_stage.mem_state_o\[51\] i_mem_slice_stage.mem_state_o\[12\] i_mem_slice_stage.mem_state_o\[36\]
+ VGND VGND VPWR VPWR _0634_ sky130_fd_sc_hd__mux2_1
XFILLER_0_100_401 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3689_ _0413_ _0815_ VGND VGND VPWR VPWR _1577_ sky130_fd_sc_hd__nor2_1
Xoutput262 net262 VGND VGND VPWR VPWR rf_wr_data_o[28] sky130_fd_sc_hd__clkbuf_4
Xoutput251 net251 VGND VGND VPWR VPWR rf_wr_data_o[18] sky130_fd_sc_hd__clkbuf_4
Xoutput240 net240 VGND VGND VPWR VPWR rf_port2_reg_o[3] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_100_445 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xoutput273 net273 VGND VGND VPWR VPWR rf_wr_data_o[9] sky130_fd_sc_hd__buf_2
XFILLER_0_100_489 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_37_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_37_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_65_487 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_80_446 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_708 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_719 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_45_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_75_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_229 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_8_507 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2991_ _0666_ _0875_ VGND VGND VPWR VPWR _0903_ sky130_fd_sc_hd__and2b_1
XFILLER_0_16_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4730_ _2287_ VGND VGND VPWR VPWR _0260_ sky130_fd_sc_hd__clkbuf_1
X_4661_ i_decode_stage.fetch_state_i\[20\] _2107_ _2234_ VGND VGND VPWR VPWR _2258_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_71_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3612_ _1199_ _1502_ _1503_ _0973_ VGND VGND VPWR VPWR _1504_ sky130_fd_sc_hd__o31a_1
X_4592_ i_decode_stage.reg_meta_o\[67\] net82 _2207_ VGND VGND VPWR VPWR _2224_ sky130_fd_sc_hd__mux2_1
XFILLER_0_101_209 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_101_85 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3543_ _0417_ _0603_ _0841_ _0413_ _1437_ VGND VGND VPWR VPWR _1438_ sky130_fd_sc_hd__o221a_1
X_3474_ _0525_ _1371_ VGND VGND VPWR VPWR _1372_ sky130_fd_sc_hd__or2_1
XFILLER_0_10_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2425_ _0365_ _0366_ _0367_ _0372_ VGND VGND VPWR VPWR _0377_ sky130_fd_sc_hd__nand4_4
X_5213_ clknet_leaf_30_clk_i _0212_ net285 VGND VGND VPWR VPWR i_decode_stage.fetch_state_i\[11\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_50_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5144_ clknet_leaf_8_clk_i net408 net297 VGND VGND VPWR VPWR i_mem_slice_stage.mem_state_o\[51\]
+ sky130_fd_sc_hd__dfrtp_1
X_2356_ i_exec_stage.data_fwd_o\[35\] i_decode_stage.decode_state_o\[126\] VGND VGND
+ VPWR VPWR _0310_ sky130_fd_sc_hd__or2b_1
X_5075_ clknet_leaf_30_clk_i i_decode_stage.decode_state_o\[19\] net285 VGND VGND
+ VPWR VPWR i_exec_stage.exec_state_o\[50\] sky130_fd_sc_hd__dfrtp_1
X_4026_ _0510_ _0961_ _0969_ _0620_ VGND VGND VPWR VPWR _1844_ sky130_fd_sc_hd__a22o_1
XFILLER_0_59_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4928_ clknet_leaf_32_clk_i _0108_ net287 VGND VGND VPWR VPWR net212 sky130_fd_sc_hd__dfrtp_2
X_4859_ clknet_leaf_38_clk_i _0039_ net282 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[43\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_30_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_30_365 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_100_253 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_85_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_57_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_38_421 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_31_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_40_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_0_237 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_505 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_516 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_527 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_538 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_549 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_56_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3190_ _0709_ _1073_ _1101_ VGND VGND VPWR VPWR _1102_ sky130_fd_sc_hd__o21a_1
XFILLER_0_56_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_88_321 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_88_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2974_ _0884_ _0885_ VGND VGND VPWR VPWR _0886_ sky130_fd_sc_hd__nor2_1
X_4713_ net210 i_decode_stage.fetch_state_i\[51\] _1927_ VGND VGND VPWR VPWR _2279_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_4_510 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4644_ _2249_ VGND VGND VPWR VPWR _0212_ sky130_fd_sc_hd__clkbuf_1
X_4575_ _2215_ VGND VGND VPWR VPWR _0177_ sky130_fd_sc_hd__clkbuf_1
X_3526_ _1065_ _1421_ _1396_ VGND VGND VPWR VPWR _1422_ sky130_fd_sc_hd__mux2_1
X_3457_ _0672_ _0650_ _0344_ VGND VGND VPWR VPWR _1356_ sky130_fd_sc_hd__mux2_1
X_3388_ _0448_ _1280_ _1286_ _1289_ VGND VGND VPWR VPWR _1290_ sky130_fd_sc_hd__or4_1
Xclkbuf_leaf_44_clk_i clknet_2_0__leaf_clk_i VGND VGND VPWR VPWR clknet_leaf_44_clk_i
+ sky130_fd_sc_hd__clkbuf_16
X_2408_ net279 i_decode_stage.decode_state_o\[123\] VGND VGND VPWR VPWR _0361_ sky130_fd_sc_hd__or2b_1
X_5127_ clknet_leaf_14_clk_i i_mem_slice_stage.pre_data\[30\] net295 VGND VGND VPWR
+ VPWR i_mem_slice_stage.mem_state_o\[30\] sky130_fd_sc_hd__dfrtp_1
X_5058_ clknet_leaf_11_clk_i net148 net292 VGND VGND VPWR VPWR i_exec_stage.exec_state_o\[33\]
+ sky130_fd_sc_hd__dfrtp_1
X_4009_ net14 _1829_ _1837_ VGND VGND VPWR VPWR i_mem_slice_stage.pre_data\[21\] sky130_fd_sc_hd__a21o_1
XFILLER_0_67_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_265 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_30_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold50 i_decode_stage.decode_state_o\[18\] VGND VGND VPWR VPWR net387 sky130_fd_sc_hd__clkdlybuf4s25_1
XFILLER_0_26_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold72 i_decode_stage.decode_state_o\[31\] VGND VGND VPWR VPWR net409 sky130_fd_sc_hd__clkdlybuf4s25_1
Xhold61 i_exec_stage.exec_state_o\[70\] VGND VGND VPWR VPWR net398 sky130_fd_sc_hd__clkdlybuf4s25_1
XFILLER_0_85_324 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xcore_330 VGND VGND VPWR VPWR core_330/HI imem_wdata_o[26] sky130_fd_sc_hd__conb_1
XFILLER_0_85_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2690_ _0451_ _0615_ _0616_ _0492_ VGND VGND VPWR VPWR _0617_ sky130_fd_sc_hd__a2bb2o_4
XANTENNA_3 _0526_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4360_ net133 _2042_ _2045_ _2077_ _2078_ VGND VGND VPWR VPWR _0099_ sky130_fd_sc_hd__a221o_1
X_3311_ _0590_ _1204_ _1208_ _1211_ _1214_ VGND VGND VPWR VPWR _1215_ sky130_fd_sc_hd__a311o_1
XTAP_324 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_313 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_302 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4291_ _0722_ _2019_ _2028_ VGND VGND VPWR VPWR _2029_ sky130_fd_sc_hd__and3_1
XFILLER_0_67_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3242_ _0525_ _0703_ VGND VGND VPWR VPWR _1148_ sky130_fd_sc_hd__nand2_1
XTAP_357 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_346 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_335 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3173_ _1084_ VGND VGND VPWR VPWR _1085_ sky130_fd_sc_hd__inv_1
XTAP_379 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_368 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_49_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_17_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_435 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2957_ i_decode_stage.reg_meta_o\[13\] _0727_ VGND VGND VPWR VPWR _0871_ sky130_fd_sc_hd__nand2_1
XFILLER_0_44_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2888_ i_exec_stage.data_fwd_o\[22\] _0726_ _0802_ VGND VGND VPWR VPWR _0803_ sky130_fd_sc_hd__o21ai_4
X_4627_ i_decode_stage.fetch_state_i\[3\] _2049_ _2234_ VGND VGND VPWR VPWR _2241_
+ sky130_fd_sc_hd__mux2_1
X_4558_ _2206_ VGND VGND VPWR VPWR _0169_ sky130_fd_sc_hd__clkbuf_1
X_4489_ _2171_ VGND VGND VPWR VPWR _0135_ sky130_fd_sc_hd__clkbuf_1
X_3509_ _0834_ _1403_ VGND VGND VPWR VPWR _1405_ sky130_fd_sc_hd__nor2_1
XTAP_880 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_405 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XTAP_891 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_94_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_75_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_12_29 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_90_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_23_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_31_471 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3860_ _0448_ _1735_ _1738_ VGND VGND VPWR VPWR _1739_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_85_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_73_305 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2811_ _0322_ VGND VGND VPWR VPWR _0726_ sky130_fd_sc_hd__buf_12
X_3791_ _1158_ _1670_ _1672_ VGND VGND VPWR VPWR _1673_ sky130_fd_sc_hd__or3b_1
XPHY_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2742_ net271 i_decode_stage.reg_meta_o\[51\] _0457_ VGND VGND VPWR VPWR _0664_ sky130_fd_sc_hd__mux2_1
XFILLER_0_14_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_78_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4412_ net145 _2118_ _1924_ VGND VGND VPWR VPWR _2119_ sky130_fd_sc_hd__mux2_1
X_2673_ _0601_ _0493_ VGND VGND VPWR VPWR _0602_ sky130_fd_sc_hd__nand2_1
XFILLER_0_1_321 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4343_ net228 net229 net230 _2055_ VGND VGND VPWR VPWR _2065_ sky130_fd_sc_hd__and4_1
X_4274_ _2016_ VGND VGND VPWR VPWR _0075_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_94_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3225_ _0590_ _1130_ _1126_ VGND VGND VPWR VPWR _1131_ sky130_fd_sc_hd__o21a_1
X_3156_ _0343_ _0568_ _1067_ VGND VGND VPWR VPWR _1068_ sky130_fd_sc_hd__a21oi_1
X_3087_ _0495_ _0980_ VGND VGND VPWR VPWR _0999_ sky130_fd_sc_hd__and2b_1
X_3989_ _1810_ _1831_ _1830_ _1814_ VGND VGND VPWR VPWR _1832_ sky130_fd_sc_hd__a22oi_4
XFILLER_0_91_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_17_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_32_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_95_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_67_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_95_485 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_82_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_90_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_63_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3010_ _2336_ _2341_ net244 VGND VGND VPWR VPWR _0922_ sky130_fd_sc_hd__and3_1
X_4961_ clknet_leaf_3_clk_i _0141_ net283 VGND VGND VPWR VPWR i_decode_stage.reg_meta_o\[22\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_58_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_86_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4892_ clknet_leaf_19_clk_i _0072_ net296 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[130\]
+ sky130_fd_sc_hd__dfrtp_4
X_3912_ _1780_ _1774_ _1781_ VGND VGND VPWR VPWR net170 sky130_fd_sc_hd__a21o_1
X_3843_ _1004_ _1012_ _1016_ VGND VGND VPWR VPWR _1723_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_6_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_73_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_6_457 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_42_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_54_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3774_ _0773_ VGND VGND VPWR VPWR _1657_ sky130_fd_sc_hd__inv_2
X_2725_ _0358_ _0643_ _0646_ _0648_ VGND VGND VPWR VPWR _0649_ sky130_fd_sc_hd__o31ai_4
XFILLER_0_54_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2656_ _0345_ _0545_ VGND VGND VPWR VPWR _0586_ sky130_fd_sc_hd__nand2_1
X_2587_ i_decode_stage.decode_state_o\[125\] i_decode_stage.decode_state_o\[41\] net178
+ i_decode_stage.decode_state_o\[137\] i_decode_stage.decode_state_o\[233\] _0338_
+ VGND VGND VPWR VPWR _0526_ sky130_fd_sc_hd__mux4_2
X_4326_ net222 net225 net226 VGND VGND VPWR VPWR _2052_ sky130_fd_sc_hd__a21oi_1
X_4257_ _2007_ VGND VGND VPWR VPWR _0067_ sky130_fd_sc_hd__clkbuf_1
X_3208_ _0645_ VGND VGND VPWR VPWR net273 sky130_fd_sc_hd__inv_2
X_4188_ _1972_ VGND VGND VPWR VPWR _0033_ sky130_fd_sc_hd__clkbuf_1
X_3139_ _0344_ _0484_ _1050_ VGND VGND VPWR VPWR _1051_ sky130_fd_sc_hd__a21oi_1
XTAP_1128 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1117 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1106 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_1139 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_92_400 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_92_433 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_92_477 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_33_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_393 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_20_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_13_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_68_430 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_68_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_95_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_433 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_28_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_3_405 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_3_449 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2510_ _0456_ VGND VGND VPWR VPWR _0457_ sky130_fd_sc_hd__buf_6
X_3490_ _0952_ _1386_ VGND VGND VPWR VPWR _1387_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_59_35 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_59_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2441_ _0391_ VGND VGND VPWR VPWR net178 sky130_fd_sc_hd__inv_2
X_5160_ clknet_leaf_15_clk_i net363 net294 VGND VGND VPWR VPWR i_mem_slice_stage.mem_state_o\[67\]
+ sky130_fd_sc_hd__dfrtp_1
X_2372_ _0325_ VGND VGND VPWR VPWR _0326_ sky130_fd_sc_hd__buf_4
XFILLER_0_75_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_5091_ clknet_leaf_27_clk_i i_decode_stage.decode_state_o\[35\] net290 VGND VGND
+ VPWR VPWR i_exec_stage.exec_state_o\[66\] sky130_fd_sc_hd__dfrtp_1
X_4111_ _1927_ VGND VGND VPWR VPWR _1928_ sky130_fd_sc_hd__buf_6
X_4042_ _0444_ _0693_ VGND VGND VPWR VPWR _1860_ sky130_fd_sc_hd__and2_1
XFILLER_0_78_205 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_91_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_86_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_19_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4944_ clknet_leaf_18_clk_i _0124_ net296 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[140\]
+ sky130_fd_sc_hd__dfrtp_4
XFILLER_0_19_349 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4875_ clknet_leaf_28_clk_i _0055_ net291 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[59\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_15_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3826_ _1706_ VGND VGND VPWR VPWR net149 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_0_54_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3757_ _0825_ _1003_ _0782_ _0430_ VGND VGND VPWR VPWR _1641_ sky130_fd_sc_hd__a31o_1
XFILLER_0_42_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2708_ _0451_ _0630_ _0632_ VGND VGND VPWR VPWR _0633_ sky130_fd_sc_hd__o21ai_4
X_3688_ _1479_ _1575_ _0448_ _1219_ VGND VGND VPWR VPWR _1576_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_100_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2639_ _0558_ _0570_ _0394_ VGND VGND VPWR VPWR _0571_ sky130_fd_sc_hd__mux2_1
Xoutput252 net252 VGND VGND VPWR VPWR rf_wr_data_o[19] sky130_fd_sc_hd__clkbuf_4
Xoutput230 net230 VGND VGND VPWR VPWR imem_addr_o[8] sky130_fd_sc_hd__buf_2
Xoutput241 net241 VGND VGND VPWR VPWR rf_port2_reg_o[4] sky130_fd_sc_hd__buf_2
XFILLER_0_100_457 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xoutput263 net263 VGND VGND VPWR VPWR rf_wr_data_o[29] sky130_fd_sc_hd__clkbuf_4
Xoutput274 net274 VGND VGND VPWR VPWR rf_wr_en_o sky130_fd_sc_hd__clkbuf_4
X_4309_ _1928_ _2028_ VGND VGND VPWR VPWR _2041_ sky130_fd_sc_hd__nor2_1
X_5289_ clknet_leaf_9_clk_i _0288_ VGND VGND VPWR VPWR i_exec_stage.data_fwd_o\[23\]
+ sky130_fd_sc_hd__dfxtp_1
XFILLER_0_97_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_69_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_65_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_80_458 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_21_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_709 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2990_ _0881_ _0900_ _0901_ VGND VGND VPWR VPWR _0902_ sky130_fd_sc_hd__a21o_1
XFILLER_0_83_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_68_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4660_ _2257_ VGND VGND VPWR VPWR _0220_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_56_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3611_ _0417_ _0622_ _0972_ _1198_ VGND VGND VPWR VPWR _1503_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_0_24_341 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_4591_ _2223_ VGND VGND VPWR VPWR _0185_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_10_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3542_ _1198_ _0841_ VGND VGND VPWR VPWR _1437_ sky130_fd_sc_hd__nand2_1
XFILLER_0_101_97 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3473_ _1327_ _1370_ _0421_ VGND VGND VPWR VPWR _1371_ sky130_fd_sc_hd__mux2_1
XFILLER_0_3_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2424_ _0360_ _0361_ _0364_ _0371_ VGND VGND VPWR VPWR _0376_ sky130_fd_sc_hd__nand4_4
X_5212_ clknet_leaf_30_clk_i _0211_ net285 VGND VGND VPWR VPWR i_decode_stage.fetch_state_i\[10\]
+ sky130_fd_sc_hd__dfrtp_1
X_5143_ clknet_leaf_15_clk_i net362 net295 VGND VGND VPWR VPWR i_mem_slice_stage.mem_state_o\[50\]
+ sky130_fd_sc_hd__dfrtp_1
X_2355_ i_exec_stage.data_fwd_o\[34\] i_decode_stage.decode_state_o\[125\] VGND VGND
+ VPWR VPWR _0309_ sky130_fd_sc_hd__or2b_1
X_5074_ clknet_leaf_42_clk_i net387 net280 VGND VGND VPWR VPWR i_exec_stage.exec_state_o\[49\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_79_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4025_ _0510_ _0961_ _0986_ _0505_ VGND VGND VPWR VPWR _1843_ sky130_fd_sc_hd__o22ai_1
XFILLER_0_19_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_19_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4927_ clknet_leaf_29_clk_i _0107_ net291 VGND VGND VPWR VPWR net210 sky130_fd_sc_hd__dfrtp_1
X_4858_ clknet_leaf_33_clk_i _0038_ net288 VGND VGND VPWR VPWR i_decode_stage.decode_state_o\[42\]
+ sky130_fd_sc_hd__dfrtp_1
XFILLER_0_62_458 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3809_ _0762_ _1670_ _0756_ VGND VGND VPWR VPWR _1690_ sky130_fd_sc_hd__o21ai_1
X_4789_ i_exec_stage.data_fwd_o\[25\] net146 _1838_ VGND VGND VPWR VPWR _2317_ sky130_fd_sc_hd__mux2_1
XFILLER_0_42_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_30_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_100_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_30_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_265 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_38_433 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_38_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_80_288 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_0_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_506 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_517 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_528 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_539 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_91_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2973_ _0447_ _0695_ VGND VGND VPWR VPWR _0885_ sky130_fd_sc_hd__nor2_1
XFILLER_0_56_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4712_ _2278_ VGND VGND VPWR VPWR _0251_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_71_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4643_ i_decode_stage.fetch_state_i\[11\] _2077_ _2234_ VGND VGND VPWR VPWR _2249_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_97_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4574_ i_decode_stage.reg_meta_o\[58\] net72 _2207_ VGND VGND VPWR VPWR _2215_ sky130_fd_sc_hd__mux2_1
XFILLER_0_52_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3525_ _0545_ _1216_ VGND VGND VPWR VPWR _1421_ sky130_fd_sc_hd__nand2_1
XFILLER_0_97_87 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_3456_ _0650_ _0919_ VGND VGND VPWR VPWR _1355_ sky130_fd_sc_hd__nand2_1
X_3387_ _1287_ _1288_ VGND VGND VPWR VPWR _1289_ sky130_fd_sc_hd__nor2_1
X_2407_ i_decode_stage.decode_state_o\[121\] net277 VGND VGND VPWR VPWR _0360_ sky130_fd_sc_hd__or2b_1
X_5126_ clknet_leaf_14_clk_i i_mem_slice_stage.pre_data\[29\] net294 VGND VGND VPWR
+ VPWR i_mem_slice_stage.mem_state_o\[29\] sky130_fd_sc_hd__dfrtp_1
X_5057_ clknet_leaf_12_clk_i net147 net293 VGND VGND VPWR VPWR i_exec_stage.exec_state_o\[32\]
+ sky130_fd_sc_hd__dfrtp_1
X_4008_ net13 _1829_ _1837_ VGND VGND VPWR VPWR i_mem_slice_stage.pre_data\[20\] sky130_fd_sc_hd__a21o_1
XFILLER_0_79_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_94_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_47_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_393 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_62_277 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_30_152 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xhold40 i_exec_stage.exec_state_o\[52\] VGND VGND VPWR VPWR net377 sky130_fd_sc_hd__clkdlybuf4s25_1
Xhold62 i_exec_stage.exec_state_o\[51\] VGND VGND VPWR VPWR net399 sky130_fd_sc_hd__clkdlybuf4s25_1
Xhold51 i_exec_stage.exec_state_o\[57\] VGND VGND VPWR VPWR net388 sky130_fd_sc_hd__clkdlybuf4s25_1
Xhold73 i_exec_stage.exec_state_o\[68\] VGND VGND VPWR VPWR net410 sky130_fd_sc_hd__clkdlybuf4s25_1
Xcore_320 VGND VGND VPWR VPWR core_320/HI imem_wdata_o[16] sky130_fd_sc_hd__conb_1
Xcore_331 VGND VGND VPWR VPWR core_331/HI imem_wdata_o[27] sky130_fd_sc_hd__conb_1
XFILLER_0_93_380 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_5_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_1_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_4 _0548_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3310_ _0886_ _0896_ _1213_ VGND VGND VPWR VPWR _1214_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_6_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_314 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_303 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4290_ _1930_ _1938_ VGND VGND VPWR VPWR _2028_ sky130_fd_sc_hd__nand2_1
XFILLER_0_67_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3241_ _1144_ _1146_ _0892_ VGND VGND VPWR VPWR _1147_ sky130_fd_sc_hd__o21ai_1
XTAP_358 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_347 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_336 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_325 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3172_ _1081_ _1083_ _0527_ VGND VGND VPWR VPWR _1084_ sky130_fd_sc_hd__mux2_1
XTAP_369 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_13_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_263 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_17_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2956_ _0441_ net271 VGND VGND VPWR VPWR _0870_ sky130_fd_sc_hd__nand2_1
X_2887_ i_decode_stage.reg_meta_o\[27\] _0727_ _0386_ _0801_ VGND VGND VPWR VPWR _0802_
+ sky130_fd_sc_hd__a211o_1
X_4626_ i_decode_stage.fetch_state_i\[2\] _1840_ _2043_ VGND VGND VPWR VPWR _0203_
+ sky130_fd_sc_hd__o21a_1
X_4557_ i_decode_stage.reg_meta_o\[50\] net95 _2179_ VGND VGND VPWR VPWR _2206_ sky130_fd_sc_hd__mux2_1
X_4488_ i_decode_stage.reg_meta_o\[16\] net100 _2012_ VGND VGND VPWR VPWR _2171_ sky130_fd_sc_hd__mux2_1
X_3508_ _0834_ _1403_ VGND VGND VPWR VPWR _1404_ sky130_fd_sc_hd__nand2_1
X_3439_ _1305_ _1267_ _1338_ _1308_ VGND VGND VPWR VPWR _1339_ sky130_fd_sc_hd__o31a_1
XTAP_870 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_417 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_5109_ clknet_leaf_14_clk_i i_mem_slice_stage.pre_data\[12\] net294 VGND VGND VPWR
+ VPWR i_mem_slice_stage.mem_state_o\[12\] sky130_fd_sc_hd__dfrtp_1
XTAP_892 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_881 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_67_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_483 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_101_393 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
Xinput130 rf_rs2_i[9] VGND VGND VPWR VPWR net130 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_73_317 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
X_2810_ _0532_ VGND VGND VPWR VPWR _0725_ sky130_fd_sc_hd__inv_2
X_3790_ _1657_ _1638_ _1671_ _0764_ VGND VGND VPWR VPWR _1672_ sky130_fd_sc_hd__a211o_1
XPHY_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_leaf_43_clk_i clknet_2_0__leaf_clk_i VGND VGND VPWR VPWR clknet_leaf_43_clk_i
+ sky130_fd_sc_hd__clkbuf_16
X_2741_ i_mem_slice_stage.mem_state_o\[78\] _0452_ _0663_ _0455_ VGND VGND VPWR VPWR
+ net271 sky130_fd_sc_hd__a22o_1
X_2672_ i_decode_stage.decode_state_o\[117\] VGND VGND VPWR VPWR _0601_ sky130_fd_sc_hd__buf_6
X_4411_ _2116_ _2117_ VGND VGND VPWR VPWR _2118_ sky130_fd_sc_hd__nor2_1
XFILLER_0_41_225 VGND VGND VPWR VPWR sky130_ef_sc_hd__decap_12
XFILLER_0_1_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4342_ net159 _2047_ _2048_ _2063_ _2064_ VGND VGND VPWR VPWR _0095_ sky130_fd_sc_hd__o221a_1
XFILLER_0_68_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4273_ i_decode_stage.decode_state_o\[133\] net55 _2012_ VGND VGND VPWR VPWR _2016_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_94_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3224_ _0662_ _1115_ _1119_ VGND VGND VPWR VPWR _1130_ sky130_fd_sc_hd__a21oi_1
.ends
